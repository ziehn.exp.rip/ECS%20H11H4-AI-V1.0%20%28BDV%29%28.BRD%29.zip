# Allegro board ECS H11H4-AI-V1.0-OK.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
-12V: length 90.5
  TOP w0.254: v2(89.7,12.71) 89.73,12.74 C555.1 C556.1 91.5,13.8 93.08,13.8 v2(93.64,14.36) ; v2(135.74,14.8) 135.74,16.53 136.51,17.3 139.06,17.3 139.97,18.22 146.34,18.22 148.54,20.41 148.54,22.95 148.18,23.31 148.18,24.83 149.07,25.72 158.77,25.72 160,26.95 C494.1 159.79,27.36 D23.N
  BOTTOM w0.254: ATX_POWER.4 86.21,12.71 v2(89.7,12.71) ; v2(93.64,14.36) 93.83,14.55 117.39,14.55 119.19,12.74 132.9,12.74 134.96,14.8 v2(135.74,14.8)
AVDDREG1: length 0.8
  TOP w0.203: 60.6,161.54 U19.23
  vias: v1(60.73,160.8)
GND: length 1101.6
  TOP w0.089: 59.83,97.35 59.35,97.35
  TOP w0.102: CPU.D4 107.17,129.28
  TOP w0.114: 107.64,132.48 v7(107.64,132.5)
  TOP w0.127: v4(64.3,105.61) 64.3,104.21 63.92,103.83 63.92,102.88 63.09,102.05 v4(62.65,102.05) 58.9,102.05 v4(57.76,100.91)
  TOP w0.152: v4(49.12,77.73) 48.79,78.07 PCH1.AC45 ; PCH1.BE32 37.36,84.02 v4(37.44,84.02) ; CPU.A15 v4(117.24,132.71) ; v4(60.17,91.32) 60.04,91.46 PCH1.A18 ; v2(48.4,100.61) 48.77,100.23 PCH1.AC1 ; v4(60.24,84.64) PCH1.A32 ; v4(46.33,77.48) 46.51,77.66 PCH1.AH45 ; v4(37.44,89.15) 37.45,89.17 PCH1.BE23 ; v4(51.28,77.67) 51.06,77.89 PCH1.V45 ; v4(60.15,82.34) PCH1.A37 59.52,82.26 PCH1.B37 PCH1.C37 ; v4(37.11,86.84) 37.17,86.9 PCH1.BE28 ; PCH1.BE14 35.65,93.72 v4(35.41,93.48) ; v4(46.57,102.54) 46.5,102.47 PCH1.AH1 ; PCH1.BE18 37.13,91.44 v4(36.95,91.26) ; PCH1.P45 v4(53.33,77.79) ; PCH1.BE9 37.05,96.01 36.87,96.19 ; CPU.A17 v4(119.07,132.72) ; CPU.A13 v4(115.42,132.66)
  TOP w0.178: PCH1.AW13 40.79,94.4 v4(40.48,94.71) ; PCH1.AM45 44.24,77.85 v4(43.88,77.49) ; v6(38.93,92.55) 39.06,92.67 PCH1.BB16 ; v6(38.94,88) 39.07,88.13 PCH1.BB25 ; PCH1.BB21 39.04,90.4 v6(38.93,90.29) ; PCH1.B25 PCH1.A25 v4(60.17,87.95) ; PCH1.AU45 v2(41.94,77.29)
  TOP w0.203: PCH1.AU1 41.93,100.68 v4(41.75,100.86) ; v2(172.25,17.09) 172.44,16.9 U35.35 ; CPU.AV38 140.48,97.55 140.02,98.01 v4(140.02,98.62) ; CODEC.7 18.96,179.14 v2(19.03,179.08) ; U35.71 v2(184.26,19.7) ; CPU.AW3 106.27,97.56 106.73,98.02 v4(106.73,98.65) 106.08,98.65 105.63,98.19 CPU.AV2 ; U35.4 v2(171.43,28.5) ; U39.6 38.22,158.46 37.78,158.46 37.25,157.93 v2(37.25,157.68) ; v4(37.48,80.49) 37.71,80.72 PCH1.BE40 ; U31.4 48.64,28.32 v2(48.83,28.5) 48.62,28.72 U31.5 ; 105.45,197.49 105.56,197.38 U4.24 106.21,197.01 106.24,196.97 106.24,196.82 v4(106.51,196.55) ; U24.11 U24.15 ; v4(37.44,82.49) 37.61,82.32 PCH1.BE37 ; v4(117.16,101.39) 118.07,101.39 ; CPU.V1 104.42,116.5 103.33,116.5 v7(102.84,116.02) ; v2(37.31,160.86) 37.45,160.86 37.84,160.46 U39.1 ; v4(40.48,94.71) 39.69,94.71 PCH1.BB11 ; U18.5 102.65,167.7 v2(102.85,167.9) 103.05,167.7 U18.4
  TOP w0.254: v2(120.61,198.82) 120.61,197.1 121.13,196.58 C19.2 ; CPU.T1 104.61,118.31 105.03,117.89 105.78,117.89 CPU.U3 ; PCH1.B40 59.14,80.09 59.51,79.72 PCH1.A42 ; U21.6 188.57,140.78 v2(188.82,141.04) ; R308.2 45.73,112.25 46.13,112.64 v2(46.28,112.64) ; VGA.6 115.4,205.83 115.4,202.77 113.96,201.33 v2(113.96,200.98) ; v2(103.8,172.15) 103.8,172.18 104.03,172.41 SP1.2 ; v4(40.18,77.44) 40.32,77.58 PCH1.AY45 ; v2(157.01,202) 157.23,201.78 HDMI.17 ; U33.11 156.7,31.15 v2(156.39,31.46) ; C594.1 14.04,35.79 13.68,36.15 13.68,37.27 14.2,37.79 v2(15.47,37.79) ; SP7.2 80.87,142.75 v2(80.11,141.99) ; v6(38.93,85.71) 39.07,85.85 PCH1.BB30 ; v4(59.8,100.2) 60.45,100.84 63.16,100.84 64.81,102.49 64.81,103.7 65.38,104.27 65.38,104.72 65.95,105.29 v2(65.95,106.05) 65.95,107.32 68.05,109.42 71.07,109.42 73.19,107.3 v2(73.19,102.3) 73.19,98.05 71.16,96.02 67.98,96.02 65.13,98.88 v2(64.68,98.88) 61.35,98.88 59.83,97.35 ; C9.1 114.54,198.81 114.57,198.81 115.61,197.77 115.61,197.03 115.1,196.52 C24.2 ; C358.2 25.85,78.7 v2(26.01,78.86) ; HDMI.11 v2(154.23,202) ; v2(116.12,201.3) 117.91,203.1 VGA.7 ; v4(58.01,77.6) 58.24,77.83 PCH1.D45 ; HDMI.8 v2(152.73,202) ; U17.6 v2(137.2,164.92) ; 54.78,106.5 v2(54.78,107.32) ; U16.6 117.77,164.98 v2(117.7,164.92) ; v7(123.54,131.01) 123.65,130.9 CPU.C22 ; 120.18,199.52 120.37,199.71 120.37,201.36 122.4,203.4 122.4,204.54 120.88,206.06 VGA.8 120.2,203.14 v2(118.32,201.25) ; CPU.C16 117.7,129.73 117.7,128.82 CPU.E15 116.79,128.82 v7(115.87,128.82) ; v6(45.43,79.32) 45.43,79.7 PCH1.AK42 ; 59.35,97.35 PCH1.B6 ; CPU.AR16 CPU.AT15 ; v4(41.75,89.07) 41.37,88.69 PCH1.AV24 ; HDMI.5 v2(151.23,202) ; 56.05,106.5 56.05,106.94 v2(55.63,107.36) ; v2(23.91,47.25) 23.91,47.22 C417.2 R460.1 ; CPU.W33 136.36,115.11 v7(137.28,115.11) ; v7(103.81,110.99) CPU.AD1 ; v2(121.13,195.65) 121.39,195.4 121.39,194.35 C40.2 ; HDMI.2 v2(149.73,202)
  TOP w0.305: CPU.P35 v7(137.28,118.76) ; CPU.AJ32 135.16,105.67 135.16,105.67 v4(135.48,105.99) ; v7(135.45,110.53) CPU.AC33 v7(136.36,110.53) CPU.AC34 ; v7(137.28,120.59) CPU.M35 ; CPU.AB39 141.95,112.46 v7(141.96,112.46) ; v7(137.28,128.82) CPU.C35 ; v7(140.93,124.25) CPU.H39 ; v7(139.1,124.25) CPU.H37 ; CPU.AE8 v7(111.3,109.62) ; v7(127.76,126.99) CPU.F26 ; v7(140.93,122.42) CPU.K39 ; 124.92,103.68 CPU.AL21 ; v7(131.42,130.65) CPU.B30 ; v7(103.8,109.21) 103.85,109.16 CPU.AF1 ; CPU.G8 110.95,126.43 110.95,125.72 CPU.H8 ; v7(137.28,116.93) CPU.T35 ; v7(129.59,130.65) CPU.B28 ; v2(188.82,123.83) 188.82,123.64 188.57,123.39 U23.6 ; v7(129.59,121.51) CPU.M29 ; v7(108.56,115.11) CPU.Y5 ; CPU.M12 v7(114.05,122.42) CPU.L11 ; v7(129.59,126.99) CPU.F28 ; v7(140.93,120.59) CPU.M39 ; v7(139.1,115.11) CPU.V37 ; v7(137.28,115.11) CPU.V35 ; v7(133.62,125.16) CPU.G31 ; v7(137.28,126.99) CPU.E35 ; v7(131.42,128.82) CPU.D30 ; v7(134.53,121.51) CPU.L32 ; v7(139.1,120.59) CPU.M37 ; v6(47.68,79.33) 47.56,79.45 PCH1.AE42 ; v7(125.02,123.34) 125.02,123.34 CPU.K24 ; CPU.R33 v7(135.4,117.8) ; v7(131.42,126.99) CPU.F30 ; v7(135.45,126.99) CPU.E33 ; v7(139.1,116.93) CPU.T37 ; v7(125.93,121.51) CPU.M25 ; CPU.N33 v7(135.42,119.65) ; v7(126.85,125.16) CPU.H26 ; CPU.P37 v7(139.1,118.76) ; CPU.AK9 v4(112.2,105.94) ; v7(139.1,128.82) CPU.C37 ; v7(105.81,125.16) CPU.J3 ; v7(140.93,115.11) CPU.V39 ; v7(118.62,121.51) CPU.M17 ; v4(124.47,104.13) 124.47,104.13 ; v7(129.59,125.16) CPU.H28 ; v7(131.42,125.16) CPU.H30 ; v7(135.45,128.82) CPU.C33 ; v7(124.1,121.51) CPU.M23 ; v7(140.02,114.19) CPU.Y37 ; CPU.AA33 v7(135.45,112.36) ; PCH1.AV17 41.37,91.81 v4(40.96,91.4) 40.61,91.05 PCH1.AW19 ; v7(135.45,122.42) CPU.K33 v7(136.36,123.34) CPU.J34 v7(137.28,124.25) CPU.H35 ; CPU.B26 v7(127.76,130.65) ; v7(122.27,121.51) CPU.M21 ; v7(138.19,114.19) CPU.Y35 ; v7(137.28,122.42) CPU.K35 ; v7(133.62,128.82) CPU.C31 ; v7(127.76,121.51) CPU.M27 ; v7(139.1,122.42) CPU.K37 ; v7(131.42,123.34) CPU.K30 ; CPU.AT12 116.79,99.02 117.53,99.02 CPU.AT13 ; v7(140.93,116.93) CPU.T39 ; v7(126.85,123.34) CPU.K26 ; v7(120.45,121.51) CPU.M19 ; CPU.P39 v7(140.93,118.76) ; v7(135.45,125.16) CPU.G33 ; CPU.AR17 CPU.AR16 ; v7(133.62,126.99) CPU.E31 ; v7(129.59,123.34) CPU.K28 ; CPU.AA8 v2(111.58,113.73) ; v7(129.59,128.82) CPU.D28
  TOP w0.33: v7(114.03,130.66) 114.03,130.85 114.04,130.87 114.04,131.38 113.64,131.78 113.64,131.97 CPU.A11
  TOP w0.356: v7(105.81,123.34) CPU.L3 ; v7(103.81,120.06) 103.88,120.13 CPU.P1 ; CPU.AR5 v4(107.64,100.48) CPU.AT5 ; CPU.AY27 v4(130.42,94.79) ; CPU.AT24 127.78,99 128.49,99 CPU.AT25 128.59,99.13 v4(129.01,98.65) 129.48,99.1 CPU.AT26 ; v7(123.19,128.82) CPU.E21 ; CPU.AG2 v7(105.81,107.79) CPU.AG3 ; CPU.G6 v7(109.47,126.99) CPU.F7 ; CPU.AK30 v4(133.62,104.13) CPU.AL30 ; v4(112.2,96.8) CPU.AY9 ; CPU.AM34 v4(137.28,102.28) ; CPU.N3 v7(105.81,121.51) ; v4(123.58,99.56) 123.58,99.59 CPU.AR20 ; v7(119.53,130.65) CPU.C18 ; CPU.AN19 123.1,101.87 v4(122.67,102.3) 123.1,102.74 CPU.AM19 v4(123.56,103.22) ; v4(131.79,98.65) 132.25,99.09 CPU.AT29 CPU.AT30 ; CPU.AR20 124.19,99.84 124.75,99.84 CPU.AR21 125.08,99.87 125.69,99.87 CPU.AR22 CPU.AR23 126.96,99.81 127.47,99.81 CPU.AR24 v4(128.13,100.48) CPU.AP24 v4(128.13,101.39) CPU.AN24 ; CPU.AR20 v4(123.55,100.49) 123.1,100.04 CPU.AR19 ; v4(142.96,104.59) CPU.AK40 ; CPU.AN36 v4(139.1,102.28) 138.65,102.74 CPU.AM36 ; v4(110.39,102.28) CPU.AN7 ; CPU.AR30 v4(132.7,100.5) 133.19,100.93 CPU.AP30 ; v7(109.47,125.16) CPU.J6 ; v7(115.87,126.99) CPU.G13 ; v4(134.54,99.56) 134.08,99.1 CPU.AT31 ; v4(134.54,99.56) CPU.AR31 ; v4(134.54,99.56) CPU.AR32 ; v7(142.96,106.42) CPU.AH40 ; v4(113.13,105.05) CPU.AK10 112.64,105.5 v4(112.2,105.94) ; CPU.AP11 v4(115.33,100.48) CPU.AR11 ; CPU.J12 v7(114.96,125.16) ; v7(122.28,126.1) 122.73,125.65 CPU.H21 ; CPU.AC34 137.02,111.19 137.53,111.19 CPU.AC35 ; v4(139.1,107.79) CPU.AF37 v4(140.02,107.79) ; v4(139.1,107.79) CPU.AG36 ; v4(139.1,107.79) CPU.AF36 ; v4(103.78,102.76) CPU.AN1 ; CPU.AL27 v4(130.87,104.13) ; CPU.E17 119.08,128.36 v7(119.52,128.8) ; v4(111.3,98.65) CPU.AV9 ; CPU.AL3 106.25,104.59 v4(105.81,104.16) 105.38,104.59 CPU.AL2 ; CPU.C12 114.48,130.19 v7(114.03,130.66) ; v7(113.13,122.42) CPU.L11 ; CPU.AG5 v2(107.64,108.7) ; CPU.AD36 v4(139.1,109.62) CPU.AE36 ; CPU.AJ36 v7(139.1,105.99) CPU.AH36 ; CPU.C20 v7(121.82,130.88) ; CPU.J20 v7(121.35,125.17) ; CPU.AN11 v4(115.33,102.3) CPU.AM11 ; CPU.K15 v7(116.79,124.25) CPU.K14 ; CPU.AM5 v4(107.64,104.16) CPU.AL5 ; v4(130.87,103.22) CPU.AM27 130.32,102.66 130.32,101.95 CPU.AN27 130.44,101.85 v4(130.91,101.39) 130.44,100.93 CPU.AP27 130.32,100.83 130.32,100.12 130.42,100.02 CPU.AR27 130.33,99.93 130.33,99.19 CPU.AT27 130.42,99.08 v4(130.91,98.65) 131.33,99.08 CPU.AT28 ; CPU.AR35 v4(137.28,100.48) CPU.AR34 ; CPU.AM33 v4(135.45,102.28) ; v4(118.07,104.13) CPU.AL14 v4(118.07,103.22) CPU.AM14 ; CPU.AW32 134.99,95.8 v4(135.09,95.7) ; CPU.AD38 140.48,110.08 140.89,109.66 v4(140.93,109.62) 140.97,109.66 141.39,110.08 CPU.AD39 ; CPU.AJ8 v7(111.3,105.96) CPU.AK8 ; CPU.M15 v7(116.79,121.51) ; v4(115.33,103.22) CPU.AL11 v4(115.33,104.13) ; v7(106.73,119.68) CPU.P4 ; 139.56,99.08 v4(139.1,98.62) 138.65,99.08 CPU.AT36 ; 139.56,99.08 v4(140.02,98.62) 140.48,99.08 CPU.AT38 140.48,99.13 v4(140.93,98.67) 141.36,99.1 CPU.AT39 ; 139.56,99.08 CPU.AT37 ; CPU.AM31 v4(133.62,103.22) ; CPU.AR3 v4(105.81,100.48) CPU.AR2 ; v7(142.96,108.25) CPU.AF40 ; v7(103.81,127.45) CPU.F1 ; CPU.AU25 128.59,98.16 v4(129.01,97.73) 129.05,97.73 CPU.AV26 ; v4(109.47,102.28) CPU.AN6 ; CPU.K19 CPU.J18 v7(119.53,125.16) ; CPU.AR1 v4(103.78,100.93) ; CPU.W3 v7(105.81,116.02) ; CPU.AN5 v4(107.64,102.28) CPU.AP5 ; v7(125.93,126.08) 125.93,126.08 CPU.H24 ; v7(105.81,126.99) CPU.G3 ; v7(138.19,105.96) CPU.AJ35 ; v7(115.87,123.34) CPU.L13 ; CPU.L32 v7(135.45,122.42) ; v7(121.38,126.99) CPU.G19 ; v4(136.36,105.96) CPU.AJ33 ; v4(106.73,104.16) 107.16,104.59 CPU.AL4 ; CPU.AM32 v4(134.53,102.28) ; CPU.AL1 v4(103.73,104.59) ; CPU.AE3 v7(105.81,110.51) ; v7(117.72,125.15) CPU.J16 CPU.K17 ; CPU.AM38 v4(140.94,102.28) CPU.AM39 ; CPU.K7 v7(109.47,123.34) CPU.L6 ; v4(109.47,105.96) CPU.AK7 ; v7(106.73,123.34) CPU.K4 ; CPU.R6 v7(109.47,119.68) ; CPU.AU30 133.16,98.16 v4(133.59,97.73) 133.16,97.3 CPU.AV30 CPU.AW30 CPU.AY30 133.16,94.8 v4(133.3,94.66) ; v4(138.75,95.7) 138.65,95.8 CPU.AW36 ; v7(106.73,126.99) CPU.F4 ; CPU.AJ5 v7(107.64,105.96) CPU.AK5 ; v7(142.96,110.08) CPU.AD40 ; v7(121.36,128.82) CPU.E19 ; CPU.AK6 v7(108.56,105.96) ; v4(119.9,102.3) CPU.AN16 v4(119.9,101.39) ; CPU.AP14 118.07,101.39 CPU.AN14 ; v4(121.76,99.56) CPU.AR18 ; v4(121.76,99.56) CPU.AT17 ; v4(121.76,99.56) CPU.AR17 ; CPU.F22 v7(124.1,126.99) CPU.G22 ; v4(136.36,106.88) CPU.AH33 ; CPU.AH37 v7(140.02,105.99) 140.45,106.42 CPU.AH38 v4(140.93,105.99) ; v4(136.36,107.79) CPU.AG33 ; v7(106.73,121.51) CPU.M4 ; v4(112.22,103.22) CPU.AN10 112.67,102.74 v4(113.13,102.28) ; v4(108.1,95.7) CPU.AY5 ; CPU.AN30 133.19,101.85 v4(132.7,101.39) ; CPU.AK36 v4(139.1,104.16) 138.65,103.7 CPU.AL36 ; CPU.AK26 v4(129.94,105.03) ; v4(112.22,102.28) CPU.AN9 ; v4(140.02,100.48) CPU.AP37 ; v4(109.93,95.7) CPU.AY7 ; CPU.AJ4 v7(106.73,105.96) ; v4(132.7,103.22) CPU.AM30 ; v4(140.03,102.28) CPU.AM37 ; CPU.C24 CPU.D24 125.47,129.28 v7(125.02,128.82) 124.56,128.36 CPU.E23 ; CPU.AT13 CPU.AT14 118.53,99.13 v4(118.97,99.56) CPU.AR14 ; v7(106.7,107.79) CPU.AG4 ; v4(140.02,109.62) CPU.AD37 ; CPU.AK16 v4(119.9,105.05) ; v7(112.22,127.91) CPU.F10 ; CPU.AN22 v4(126.3,102.3) CPU.AN23 ; v7(103.81,121.93) 103.85,121.96 CPU.M1 ; CPU.AV28 v4(131.76,97.73) ; v4(136.92,95.7) 136.82,95.8 CPU.AW34 CPU.AV34 136.82,97.3 v4(137.25,97.73) 136.82,98.16 CPU.AU34 CPU.AT34 ; CPU.AK20 v4(123.56,105.05) ; CPU.AK28 v4(131.77,105.03) ; CPU.AK13 v4(117.16,105.05) ; CPU.AH5 v4(107.64,106.88) ; CPU.AK29 v4(132.69,105.03) ; CPU.AM35 v4(138.19,102.28) ; v7(105.64,113.73) CPU.AA3 ; CPU.AT12 116.7,99.13 v4(116.24,99.56) CPU.AT11 ; v4(140.02,104.16) CPU.AK37 ; v4(142.96,99.1) CPU.AT40 ; v4(110.39,107.79) CPU.AH8 ; CPU.AK17 v4(120.82,105.05) ; v4(137.28,105.05) CPU.AJ34 v7(137.28,105.96) ; CPU.N6 v7(109.47,121.51) ; CPU.AK25 v4(129.03,105.03) ; v7(109.47,117.85) CPU.U6 ; CPU.AK15 v4(118.99,105.05) ; v7(125.47,132.78) CPU.A24 CPU.B24 ; CPU.AD33 v4(136.36,109.62) CPU.AE33 ; v7(119.53,126.99) CPU.G17 ; CPU.A7 v7(109.47,131.56) ; U34.8 v2(13.75,25.15) ; CPU.AK23 v4(126.3,105.05) ; CPU.AK18 v4(121.73,105.05) ; CPU.AM17 v4(120.82,103.22) ; CPU.AT7 v4(110.39,100.48) ; CPU.AJ31 134.56,105.99 v4(134.59,105.99) ; v7(115.87,128.82) CPU.E13 ; v4(142.96,102.76) CPU.AM40 ; v7(106.73,125.16) CPU.H4 ; CPU.AR33 135.9,99.99 v4(135.45,99.54) 135.01,99.1 CPU.AT32 v4(135.47,98.64) ; 124.47,104.13 124.92,103.68 ; v7(103.81,123.79) CPU.K1 ; CPU.AU5 v4(107.64,98.65) CPU.AU4 ; CPU.AV5 v4(107.64,97.73) CPU.AW5 ; CPU.AT8 v4(111.3,99.56) CPU.AT9 ; CPU.R3 v7(105.81,119.68) ; v4(128.13,104.13) CPU.AL24 ; CPU.AL21 v4(125.39,104.13) ; CPU.G11 v7(113.13,126.08) ; CPU.AR4 v4(106.73,100.48) ; v7(136.36,108.7) CPU.AF33 ; R202.2 v2(84.37,163.58) ; CPU.AT10 v4(113.1,100.48) ; CPU.K22 v7(124.1,124.25) ; v4(142.96,100.93) CPU.AP40 ; v7(103.78,106.42) CPU.AJ1 ; v4(109.47,98.65) CPU.AU7 ; v7(108.56,128.82) CPU.E6 ; v7(108.56,116.02) CPU.W6 ; 107.17,129.28 106.74,129.74 v7(106.75,129.74) ; CPU.J10 v7(112.22,125.16) ; v4(111.3,102.28) CPU.AN8 ; v4(128.13,103.22) CPU.AM24 ; CPU.AK19 v4(122.64,105.05) ; CPU.AK12 v4(116.24,105.05) ; v4(106.73,102.28) 107.16,102.76 CPU.AN4 ; CPU.AR36 v4(139.1,100.48) CPU.AP36 ; v7(109.47,129.74) CPU.D7 ; CPU.C5 v7(107.67,130.65) ; v7(117.72,127.01) CPU.G15
  TOP w0.381: v2(21.46,76.42) 22.07,77.03 C360.2 ; v2(91.1,189.93) U6.8 v2(91.1,192.47) ; CPU.D39 CPU.D40 142.42,128.36 v2(142.84,128.79) ; Q86.1 66.76,7.55 v2(66.02,6.8) ; R158.1 176.51,170.48 v2(176.8,170.19) 176.89,170.1 R177.1 ; v4(111.3,108.7) CPU.AF8 v7(111.3,109.62) ; v7(114.04,128.8) 113.61,128.36 CPU.E11 ; CPU.AH33 v4(136.36,105.96) ; CPU.B38 140.48,130.46 v2(140.11,130.83) ; R397.2 25.57,71.35 v2(26.16,70.76) ; CPU.D37 v7(139.1,128.82) ; CPU.J32 v7(135.45,124.25) ; C356.2 32.87,81.25 32.26,80.64 v2(31.73,80.64) ; CPU.C14 116.33,130.16 v7(115.89,129.72) ; v2(142.47,195.9) U3.8 v2(145.26,195.9) ; v2(64.24,8.59) 64.49,8.85 Q86.4 ; C359.1 31.76,78 31.04,77.29 v2(31.04,77.26) ; U34.8 v2(11.02,25.15) ; CPU.R3 CPU.T4 v7(106.73,117.85) CPU.U3 ; v7(106.7,107.79) 106.27,108.22 CPU.AG3 ; CPU.AU7 CPU.AT6 ; CPU.M7 v7(110.39,121.51) CPU.N8 ; CPU.AT15 119.43,99.1 v4(118.97,99.56) ; R620.2 C594.1 14.33,35.38 14.77,34.93 Q84.4 15.3,34.63 15.65,34.28 15.65,33.8 16.12,33.33 Q84.1 17.93,33.33 C596.1 ; CPU.H7 v7(109.47,125.16) ; R369.2 C355.2 25.57,84.56 v2(25.65,84.47) ; v7(104.49,130.42) 105.13,130.42 CPU.C2 ; CPU.V8 v2(111.51,116.48) ; CPU.AD6 CPU.AD7 CPU.AD8 111.24,110.99 v2(111.54,110.69) ; CPU.AD6 CPU.AE5 CPU.AD4 v7(106.73,111.45) CPU.AC3 ; CPU.AD6 CPU.AC6 CPU.AB5 108.1,112.9 107.71,113.29 v7(107.65,113.29) ; C63.2 166.85,188.66 v2(166.92,188.73) 166.92,189.14 R53.1 ; v2(94.97,192.47) U7.8 v2(94.97,189.93) ; v2(28.17,85.48) 28.4,85.71 C352.2 ; v2(142.47,192.09) U5.8 v2(145.26,192.09) ; 105.45,197.49 103.16,199.78 C11.1 ; CPU.E9 v7(112.22,127.91) ; CPU.G8 v7(110.39,126.99) ; v7(143.04,126.51) 142.33,126.51 CPU.F40 ; C354.2 23.17,84.51 v2(23.17,83.83) 23.17,83.15 R368.2 ; CPU.D26 v7(127.76,128.82) ; v7(103.81,125.69) 103.88,125.62 CPU.H1 ; v7(108.58,131.56) 108.56,131.56 CPU.B6 ; v2(107.64,108.7) CPU.AF5 ; CPU.AG1 CPU.AG2 ; CPU.AW9 111.76,97.25 v4(112.2,96.8) ; CPU.AH40 CPU.AH39 ; C367.2 C370.2 ; CPU.AG8 v4(110.39,107.79) ; v7(135.17,116.48) CPU.U33 ; v2(27.1,73.09) 27.1,73.37 26.71,73.77 C364.2 ; v7(140.02,127.91) CPU.E37 ; C363.2 v2(25.85,75.96) ; CPU.R8 v2(111.63,119.22) ; v7(110.39,130.65) CPU.C8 ; v2(13.75,21.02) U36.8 11.21,21.02 v2(11.02,20.83) ; v7(112.22,125.16) CPU.H9 ; v7(105.83,128.81) CPU.E3 ; CPU.C10 v7(112.22,129.74)
  TOP w0.406: v2(120.61,198.82) 120.61,199.09 120.18,199.52 U1.2 ; 36.87,96.19 36.47,96.59 v4(36.42,96.59) ; U2.2 v2(126.19,199.52)
  TOP w0.457: U27.3 v2(13.68,47) ; U30.2 v2(13.25,29.28) ; C491.2 v2(13.69,27.06)
  TOP w0.508: C2.1 180.51,202.95 v2(180.57,202.89) ; v2(136.31,185.33) R83.2 C75.2 ; R330.2 C327.1 v2(9.47,105.57) ; v2(17.53,173.68) 17.06,173.68 C132.2 16.88,172.84 v2(17.5,172.84) ; v2(161.27,29.91) 161.58,29.91 161.71,29.79 Q48.E ; v2(71.02,134.71) 71.37,135.07 C239.1 ; R144.1 160.6,174.28 v2(160.88,174) 160.92,174 R145.1 C123.1 ; C88.2 v2(56.74,182.06) ; v2(187.36,76.02) 187.2,76.17 C361.2 ; C435.2 v2(134.72,44.14) ; R471.2 C453.1 127.93,35.44 v2(128.18,35.69) ; C116.1 164.57,175.71 v2(164.82,175.97) ; v2(161.96,113.29) C285.2 v2(160.82,114.37) ; D9.P v2(62.97,178.25) ; v2(105.42,200.57) R15.2 103.7,200.57 C11.1 v2(101.96,200.03) ; v2(131.36,13.79) 131.36,13.12 C566.2 ; C161.2 73.24,164.99 v2(71.83,164.99) 70.61,164.99 C160.2 ; C135.1 v2(126.53,173.68) ; C118.2 v2(93.52,175.33) ; v2(57.19,156.06) R224.2 ; C407.2 27.72,54.87 27.28,55.31 v2(27.28,55.82) ; C563.1 v2(183.24,12.39) ; U13.2 v2(56.43,179.8) ; v2(166.84,170.07) 166.51,170.07 C143.1 ; v2(107.07,168.22) C145.1 C139.1 ; v2(190.48,19.31) 189.97,19.82 C534.1 ; Q28.E v2(5.37,117.42) ; v2(41,37.47) 41,36.52 C442.2 41.76,36.65 v2(41.76,37.47) ; R176.1 173.33,169.77 v2(173.33,170.06) ; CN4.7 165.41,8.27 v2(165.01,7.88) 164.59,8.3 CN4.5 ; CPU.AU1 v4(103.78,99.1) ; C515.1 93.29,21.44 v2(92.86,21.86) ; R17.2 v2(107.04,200.57) R16.2 ; C164.1 34.77,160.41 v2(34.77,160.85) ; C332.1 4.86,98.84 v2(5.33,98.37) ; v2(21.69,40.96) 22.2,40.46 Q44.S ; v2(188.65,57.07) 188.79,57.21 C392.2 ; C516.1 v2(149.33,21.44) ; v2(167.23,201.17) C4.2 ; C445.1 59.09,35.25 v2(58.52,35.82) ; C408.2 v2(56.17,55.5) ; C40.2 v2(120.72,191.74) 120.72,191.24 120.31,190.82 118.78,190.82 118.31,191.3 ; Q8.S v2(175.81,193.49) ; 24.11,54.36 24.11,54.93 v2(23.66,55.38) ; QN1.S v2(184.7,94.94) ; R140.1 158.63,175.43 v2(159.23,174.82) ; CN1.5 152.21,8.3 v2(152.63,7.88) 153.02,8.27 CN1.7 ; C434.2 127.23,44.14 v2(127.04,44.33) ; v2(155.99,43.38) 156.09,43.47 C437.2 ; C238.2 167.33,135.1 v2(166.92,134.69) ; v2(13.82,175.58) 13.4,175.17 D11.1 ; v2(45.25,180.03) R105.2 44.55,181.11 v2(44.3,180.85) ; Q50.S v2(143.36,29.79) ; C576.2 111.29,7.12 v2(110.4,6.23) ; v2(160.82,121.1) C261.2 v2(163.17,121.1) ; v2(194.73,125.42) 194.73,126.31 C255.1 195.49,126.31 v2(195.49,125.42) ; R490.1 51,29.15 v2(50.88,29.03) ; R296.2 v2(50.62,112.78) C310.2 ; C411.2 v2(127.61,55.4) ; Q42.C 46.84,53.85 v2(47.85,52.84) ; Q22.S v2(6.52,143.13) ; Q6.S v2(139.29,202.38) ; Q52.S v2(28.04,26.94) ; CN2.1 154.71,8.27 v2(155.11,7.88) 155.52,8.3 CN2.3 ; C557.2 186.13,14.83 v2(186.51,15.21) C545.2 ; C422.2 v2(125.77,44.2) ; v2(98.34,192.09) C54.2 R46.2 ; R191.1 36.27,161.21 36.61,160.86 v2(37.31,160.86) ; Q25.E v2(5.37,128.28) ; C575.2 v2(20.58,9.02) ; C551.2 168.12,15.63 v2(167.36,15.63) ; C553.2 80.33,13.75 v2(80.56,13.53) ; v2(178.03,176.85) 177.3,176.85 R128.1 ; C159.1 v2(52.96,165.68) ; v2(60.24,114.13) 60.01,113.91 C303.2 ; D13.P 8.29,163.58 v2(8.42,163.71) ; v2(191.11,15.69) 190.41,16.39 C543.2 ; v2(78.33,157.74) 78.81,158.22 C194.2 ; v2(108.94,30.74) 108.24,30.74 C476.2 108.24,29.98 v2(108.94,29.98) ; v2(49.95,170.19) C136.1 ; C170.2 21.15,162.03 PCIE16X.A4 ; C1.2 v2(177.9,204.16) ; v2(6.13,106.21) Q31.S ; R143.1 173.08,173.18 173.08,172.85 v2(172.82,172.6) 172.19,173.23 C126.2 ; Q18.C v2(30.2,174.31) ; C416.2 R459.2 v2(11.68,47.6) ; C571.2 v2(10.93,10.2) ; C499.1 42.84,25.15 v2(43.16,24.83) ; U9.2 v2(141.01,184.54) ; C173.1 v2(41.44,167.36) ; v2(163.92,172.55) 163.81,172.66 C124.1 ; R216.2 R211.2 v2(88.72,161.36) ; C588.2 27.97,9.69 v2(28.04,9.76) ; v2(29.44,99.13) C335.2 C333.2 ; v2(163.11,119.51) C268.2 v2(160.82,119.51) ; RJ6.3 v2(28.82,69.54) ; C418.2 106.37,43.66 v2(106.15,43.44) ; v2(9.98,115.83) Q30.S 8.93,116.36 9.73,117.16 C275.1 ; C597.2 133.36,34.58 133.96,33.98 v2(133.96,33.03) C467.1 ; v2(98.91,167.9) 98.43,167.42 C154.1 ; C389.1 v2(9.85,59.16) ; v2(14.71,178.12) 14.71,178.54 C105.2 ; C552.2 v2(74.56,13.5) ; C20.2 v2(122.21,195.65) ; R465.2 28.63,39.36 v2(28.3,39.69) ; C592.2 v2(64.24,11.75) ; C185.2 v2(59.03,158.13) ; D7.P 77.24,177.75 v2(77.38,177.62) ; v2(5.44,125.06) 5.84,124.66 Q26.E ; CN4.3 163.78,8.3 v2(163.36,7.88) 162.97,8.27 CN4.1 ; v2(5.46,121.51) 5.93,121.04 Q27.E ; v2(66.08,161.11) 66.08,160.18 C181.2 ; Q69.E v2(148.06,10.04) ; C494.2 v2(160,25.34) R524.1 ; v2(138.91,12.07) R581.2 C570.2 ; C147.2 v2(58.08,169.66) ; C427.1 v2(60.49,44.14) ; v2(196.19,22.42) L31.1 ; C331.2 66.02,102.49 v2(65.95,102.56) 65.95,103.35 C328.2 ; Q68.E 143.32,11.31 v2(143.38,11.25) ; R571.1 v2(61.19,12.01) ; C532.2 30.68,19.5 v2(31.09,19.5) ; C519.1 v2(153.26,20.58) ; R138.2 v2(53.51,176.28) ; C25.2 v2(116.62,195.52) 116.62,194.41 C38.2 v2(115.89,191.74) 115.89,191.24 ; v2(80.11,141.99) 79.64,141.99 C220.1 ; C92.1 178.09,181.49 v2(178.28,181.68) ; v2(44.09,70.81) 43.69,70.81 C371.2 ; v2(4.55,160.47) 4.74,160.66 R206.2 v2(3.72,161.55) ; C3.2 v2(166.15,201.24) ; v4(105.8,95.89) CPU.AY3 ; C8.1 v2(110.48,201.31) ; v2(169.9,190.82) 169.49,190.41 R55.1 ; C582.2 106.08,6.23 F_PANEL.8 ; C398.2 C395.2 v2(183.93,58.04) ; CN3.5 160.47,8.3 v2(160.88,7.88) 161.28,8.27 CN3.7 ; C454.1 v2(185.08,34.49) ; D24.1 108.82,13.12 v2(108.69,13.25) ; R37.2 102.08,192.6 v2(101.77,192.92) ; v2(31.53,95) C342.2 ; v2(191.81,14.74) 192.13,14.42 R563.2 C564.2 ; v2(60.88,169.59) 60.3,169 C148.2 ; R367.2 C353.2 v2(21,84.56) ; C559.2 v2(172.76,13.12) ; v2(141.2,173.49) C134.1 v2(142.47,174.57) ; CN3.3 159.65,8.3 v2(159.23,7.88) 158.84,8.27 CN3.1 ; C373.2 46.36,70.71 v2(46.33,70.68) ; R221.2 v2(88.78,156.44) ; RJ5.3 RJ7.3 31.17,69.11 v2(30.79,69.49) ; v2(195.11,142.56) C217.1 v2(195.11,145.1) ; 118.31,191.3 117.89,190.89 116.24,190.89 115.89,191.24 ; 118.31,191.3 v2(118.31,191.81) C39.2 119.1,194.47 119.1,195.09 119.55,195.53 v2(119.55,195.59) C18.2 ; C385.2 v2(192.35,61.82) ; C137.1 v2(146.91,173.3) ; C341.1 v2(182.35,95.89) ; C225.2 v2(125.77,141.74) ; v2(115.67,55.89) 115.48,55.7 C405.2 ; C457.2 v2(160.03,32.74) ; C206.2 v2(10.58,151.8) ; v2(113.07,200.92) 113.07,200.28 C9.1 113.96,200.13 v2(113.96,200.98) ; v2(185.97,54.68) R453.2 C400.2 ; C589.2 v2(50.33,11.02) ; v2(91.73,157.1) 91.89,156.95 R227.2 ; C112.2 21.31,175.23 v2(21.18,175.1) ; v2(48.11,45.41) 48.36,45.15 C423.2 ; C324.2 52.05,107.16 v2(51.46,107.74) 50.97,107.24 R325.2 ; C57.2 v2(142.79,189.62) ; CN1.3 151.4,8.3 v2(150.98,7.88) 150.58,8.27 CN1.1 ; Q32.S 7.15,102.81 v2(6.58,103.38) ; v2(28.59,58.04) 28.59,58.69 C388.2 ; R500.2 v2(106.91,26.99) ; v2(131.17,142.12) C223.2 v2(131.17,139.52) ; v2(34.9,165.17) 34.52,165.55 C163.1 ; SPIROM1.4 v2(38.58,59.63) ; C215.2 v2(111.1,144.6) ; v2(175.3,12.83) 175.71,12.83 C560.2 ; v2(90.65,183.27) 91.03,182.89 C89.2 ; C419.2 v2(112.43,44.2) ; R36.2 v2(110.92,193.55) ; v2(53.57,70.74) 53.95,71.13 C374.2 ; v2(174.22,172.6) 174.47,172.85 C127.2 ; v2(173.46,188.73) R68.1 ; Q46.S v2(141.07,31.31) ; v2(58.52,56.2) 58.52,55.95 57.79,55.22 C401.2 ; R275.1 11.09,130.82 v2(10.96,130.69) ; Q33.S v2(187.3,93.99) ; R149.1 170.38,173.33 C131.1 169.9,172.03 v2(170.09,171.84) ; C583.2 v2(75.19,3.82) ; C129.1 176.76,172.64 v2(176.73,172.61) ; v2(29.06,14.8) 28.77,15.09 27.88,15.09 27.18,15.79 C550.2 ; R67.1 172.38,188.28 v2(171.87,188.79) 171.3,188.22 R66.1 ; RT3.1 v2(188.67,133.01) ; R230.2 89.8,155.42 v2(89.89,155.33) 90.02,155.2 R232.2 ; v2(10.14,146.94) 9.88,146.69 C214.1 R242.1 ; C120.1 v2(107.54,173.68) ; R323.2 R324.2 v2(49.89,107.74) ; C440.2 22.45,42.36 21.69,43.12 v2(21.69,43.5) ; C142.1 v2(18.58,169.61) ; v2(180.44,53.6) C413.2 C403.2 ; C585.2 v2(67.73,21.02) ; C501.1 v2(128.5,24.58) ; C428.2 v2(61.32,44.14) ; C113.2 22.45,174.92 v2(21.84,174.31) ; Q37.S 47.82,58.68 48.34,59.2 48.34,61.49 v2(48.06,61.77) 48.06,62.17 48.37,62.49 Q35.S ; Q29.E 5.25,114.88 v2(5.37,114.75) ; v2(28.87,174.31) Q17.C ; v2(138.98,187.49) C66.2 C59.2 ; C22.2 v2(124.37,195.65) ; Q47.S v2(144.95,29.22) ; v4(118.21,11.14) 118.28,11.08 R593.2 C577.1 ; R283.2 83.1,122.16 v2(83.1,121) ; v2(65.19,166.19) R186.1 ; Q63.S v2(188.7,13.72) ; C569.2 v2(176.63,9.53) ; C480.2 v2(148.28,30.01) ; Q62.E 131.56,16.26 v2(131.39,16.1) ; C397.2 C394.2 v2(180.06,57.22) ; R126.2 v2(43.76,178.63) ; R510.1 v2(136.94,27.06) ; C425.2 54.55,44.74 v2(54.33,44.96) ; C518.1 v2(152.18,20.58) ; C17.2 118.21,195.84 v2(118.02,195.65) ; C446.1 121.7,35.38 v2(121.39,35.69) ; U8.2 v2(87.22,190.06) ; C158.2 v2(23.84,166.28) ; C86.1 164.22,182.51 v2(164.82,182.51) ; C21.2 v2(123.29,195.65) ; C203.2 73.6,153.83 v2(74.27,154.5) ; C463.1 v2(48.71,32.93) ; v2(10.26,42.77) 10.26,42.94 9.74,43.47 C439.2 ; C208.1 v2(194,147.48) ; C414.2 v2(183.3,53.6) ; C565.2 v2(196.09,12.99) ; Q16.C 24.3,174.31 24.98,173.63 v2(24.99,173.63) ; v2(109.89,146.12) 109.89,146.82 C210.2 109.07,146.75 v2(109.07,146.12) ; QN2.2 v2(183.63,88.22) ; C517.1 v2(151.11,20.58) ; R602.1 v2(52.49,6.8) ; C421.2 v2(120.12,44.2) ; C451.1 v2(190.67,34.23) ; C10.1 v2(128.6,200.93) ; Q34.S v2(195.11,93.6) ; C149.1 v2(183.24,168.47) ; Q24.S v2(7.47,132.02) ; v2(16.99,174.44) 16.99,175.01 C115.2 16.17,175.08 v2(16.17,174.44) ; C227.2 v2(143.74,141.74) ; C436.2 147.45,43.73 v2(147.74,43.44) ; v2(52.05,166.95) C155.1 ; v2(31.47,96.97) 32.36,97.86 C340.2 ; C409.2 v2(117.77,55.63) ; C521.1 v2(155.42,20.58) ; v2(140.25,169.04) 140.47,169.26 RT1.1 ; C168.1 v2(35.38,156.88) ; v2(123.55,174.88) 123.55,174.19 C133.1 122.72,174.25 v2(122.72,174.88) ; C537.1 33.22,23.28 v2(33.25,23.31) ; CN2.7 157.15,8.27 v2(156.76,7.88) 156.34,8.3 CN2.5 ; C28.1 v2(101.83,195.84) ; R90.2 C74.2 84.4,185.62 v2(84.94,185.62) ; R433.2 v2(185.55,61.89) ; v2(107.65,189.48) 107.16,189.96 C49.1 ; QN7.S v2(57.76,3.88) ; C539.2 v2(129.71,19.18) ; C178.2 v2(63.98,160.91) ; v2(94.65,44.14) C432.2 ; v2(139.93,140.79) C224.2 v2(138.85,142.12) ; C561.2 v2(179.55,13.12) ; v2(138.74,6.88) 138.37,7.24 R607.2 C595.2 ; QN3.2 v2(142.53,25.15) ; R219.2 87.16,158.44 v2(86.91,158.69) 86.62,158.98 R215.2 ; C399.2 v2(28.04,55.82) ; v2(120.69,141.29) 121.2,140.79 C222.2 121.77,140.21 v2(122.34,139.64) ; v2(160.69,129.61) C253.2 v2(163.23,129.61) ; C410.2 v2(123.1,55.5) ; v2(175.49,172.61) 175.62,172.74 C128.1 ; C7.1 v2(180.57,200.28) ; C125.1 v2(168.38,172.61) ; 115.89,191.24 115.55,190.89 114.66,190.89 114.08,191.46 114.08,195.2 114.47,195.59 v2(115.1,195.59) C24.2 ; C219.2 v2(113.07,142.5) ; C429.2 v2(70.33,44.14) ; C554.2 v2(81.48,13.53) ; v2(156.5,20.58) C522.1 C523.1 ; C572.2 v2(168.31,10.67) ; C114.2 v2(19.15,175.25) ; C438.2 v2(163.04,44.14) ; C579.1 125.13,7.44 v2(124.12,6.42) ; R625.1 56.78,11.4 v2(56.36,10.99) ; C240.1 v2(10.93,133.29) ; R329.2 v2(32.61,105.78) R322.2 ; v2(10.97,40.4) 11.02,40.35 U28.2 ; v2(62.01,116.15) 61.48,115.61 C286.2 ; D8.P v2(79.86,176.98) ; C496.1 v2(136.94,25.91) ; v2(143.18,20.47) 143.18,21.29 Q54.E 143.42,21.53 C529.1 ; C226.2 v2(134.79,141.74) ; C507.2 v2(165.77,23.82) ; C211.1 v2(111.35,146.75) ; C531.1 v2(109.23,19.79) ; C6.1 v2(180.57,201.62) ; C430.2 v2(79.79,44.14) ; C83.2 v2(125.96,183.01) ; C581.2 134.66,7.37 v2(135.1,6.93) ; C296.1 61.93,113.53 61.57,113.89 v2(61.57,114.22) ; C443.1 v2(36.65,35.12) ; C326.1 v2(195.36,104.56) ; C165.2 v2(65.25,164.6) ; Q21.S v2(6.52,144.98) ; C309.2 64.45,110.95 v2(64.9,111.4) 65.02,111.52 C308.2 ; Q14.S v2(39.85,175.08) ; v2(105.58,147.96) 106.34,147.2 C209.2 v2(106.72,146.12) ; C393.2 23.09,56.46 v2(23.47,56.84) ; v2(43.22,35.38) 43.22,34.49 C449.2 43.6,34.23 43.98,34.61 v2(43.98,35.38) ; Q67.C 116.79,11.63 v4(116.94,11.78) ; C246.1 v2(194,130.47) ; R553.1 97.83,13.15 v2(97.89,13.21) ; C13.1 v2(180.51,198.95) ; Q61.E v2(193.78,15.31) ; v2(7.47,135.9) Q23.S ; C396.2 43.06,57.12 v2(43.28,57.35) 43.44,57.5 C391.2 ; C580.1 129.79,8.74 v2(130.02,8.97) ; C488.2 v2(165.77,28.14) ; Q55.E v2(195.11,19.94) ; C520.1 v2(154.34,20.58) ; C448.1 v2(116.82,33.47) ; C322.1 v2(194.92,106.37) ; C265.1 v2(11.47,120.91) ; v2(101.32,43.38) 101.92,43.98 C433.2 ; C573.1 v2(149.39,9.15) ; C495.1 51.09,26.1 51.87,26.88 v2(51.87,26.89) ; C232.1 v2(75.98,139.57) ; v2(38.1,67.94) 38.1,68.58 C381.2 ; R326.1 v2(40.93,107.66) ; Q39.E v2(13.12,56.14) ; R254.1 v2(78.21,139.57) ; v2(18.31,175.3) 18.07,175.54 R136.2 ; C146.2 v2(57,169.69) ; C584.2 v2(81.54,3.82) ; C233.2 165.01,137.67 v2(165.39,137.29) ; R168.1 v2(105.13,171.27) ; v2(160.76,126.24) C257.2 v2(163.11,126.24) ; C12.2 v2(127.39,200.28) ; C404.2 v2(183.3,54.68) ; C201.2 v2(12.48,154.6) ; C558.2 v2(170.28,13.12) ; C16.1 v2(101.83,196.92) ; U15.2 v2(47.1,171.84) ; Q41.E v2(192.19,54.55) ; Q51.S v2(147.23,29.79) ; v2(65.25,167.26) C152.1 ; C528.2 190.6,21.09 v2(190.67,21.02) ; C415.2 v2(188.06,53.6) ; C525.1 v2(131.61,20.14) ; v2(51.84,70.78) 51.79,70.83 R395.2 ; R566.2 v2(64.36,12.91) ; Q53.E v2(136.37,21.47) ; C195.1 v2(63.41,158.76) ; C578.1 v2(121.9,9.66) ; C475.1 v2(112.81,30.42) ; Q59.S v2(97.96,18.36) ; R439.2 v2(183.72,59) ; R437.2 v2(189.74,60.9) ; v2(170.03,170.85) R161.1 ; R118.1 v2(157.46,179.14) ; C241.1 85.57,132.48 v2(85.29,132.2) ; C542.2 v2(165.77,17.09) ; C5.1 v2(101.7,202.44) ; C196.1 v2(188.13,157.23) ; C562.1 v2(182.16,12.39) ; C184.2 v2(56.87,158.08) ; C482.2 v2(136.94,29.34) ; C151.1 v2(110.72,169.04) ; Q49.S v2(29.06,29.72) ; C536.2 v2(30.71,23.28) ; C567.2 v2(187.17,10.99) ; C466.1 v2(151.71,32.68) ; C402.2 v2(114.21,56.52) ; R363.1 v2(183.68,85.29) ; C412.2 v2(129.07,55.43) ; C426.2 v2(55.82,43.44) ; C424.2 v2(52.46,43.31) ; CPU.A4 107.64,132.48 ; C568.2 v2(175.43,9.78) ; C538.2 v2(165.77,19.25) ; C556.2 v2(92.75,14.36) ; v2(112.12,13.25) 112.25,13.12 D25.1 ; QN5.E v2(66.46,10.29) ; C370.2 v2(30.9,72.4) ; C596.1 R621.2 ; C19.2 v2(121.13,195.65) ; C23.2 v2(125.45,195.65) ; C420.2 v2(116.94,43.25) ; v2(30.58,31.18) 30.58,31.63 C458.2 29.82,31.88 v2(29.82,31.18) ; R547.2 v2(11.79,17.91) ; D10.P v2(66.78,178.25) ; C486.1 v2(105.83,26.99) ; C511.2 v2(165.77,22.74) ; C390.2 v2(18.74,59.19) ; C471.2 v2(165.77,30.74) ; C431.2 v2(88.75,44.14) ; ROM1.4 v2(184.51,7.5) ; C487.1 v2(136.88,28.2)
  BOTTOM w0.254: v2(107.04,200.57) v2(105.42,200.57) ; v2(107.04,200.57) 107.04,198.77 107.72,198.09 110.67,198.09 112.14,196.62 112.14,195.32 114.55,192.91 117.2,192.91 v2(118.31,191.81) ; v2(107.04,200.57) 107.04,200.57 108.92,198.7 110.92,198.7 112.75,196.87 112.75,195.57 114.8,193.52 118.94,193.52 v2(120.72,191.74) 120.05,191.08 119.04,191.08 v2(118.31,191.81) ; v2(105.42,200.57) 105.96,200.03 105.96,199.23 105.78,199.06 105.78,198.59 106.89,197.48 110.42,197.48 111.53,196.36 111.53,195.06 114.29,192.3 115.34,192.3 v2(115.89,191.74) ; v2(105.42,200.57) 104.81,199.97 104.81,198.25 v4(106.51,196.55) v4(108.7,196.55) 110.48,196.55 110.59,196.44 110.6,196.44 110.92,196.11 110.92,194.81 114.55,191.19 115.34,191.19 v2(115.89,191.74) ; v2(115.89,191.74) 116.56,191.08 117.58,191.08 v2(118.31,191.81)
  vias: v2(6.4,34.09) v2(6.44,33.01) v2(6.44,32.02) v2(6.45,35.02) v2(8.76,92.08) v2(8.76,91.29) v2(8.76,90.48) v2(9.63,77.97) v2(9.64,77.21) v2(20.55,22.42) v2(22.07,22.74) v2(23.93,160.48) v2(23.91,159.75) v2(26.33,175.96) v2(27.09,175.96) v2(29.9,142.69) v2(30.77,160.15) v2(30.77,159.39) v2(30.77,158.57) v2(31.5,159.67) v2(31.5,158.84) v2(31.5,158.07) v2(31.73,143.58) v2(33.43,160.29) v2(33.92,70.24) v2(33.95,69.4) v2(36.55,172) v2(37.34,172) v2(40.23,111.19) v2(40.23,110.31) v2(41,116.72) v2(41,115.96) v2(41,111.19) v2(42.01,157.61) v2(42.77,157.61) v2(43.6,32.45) v2(43.6,31.69) v2(43.66,157.61) v2(44.11,164.79) v2(44.36,32.45) v2(44.36,31.69) v2(44.49,157.61) v2(44.68,163.26) v2(45.12,32.45) v2(45.12,31.69) v2(45.31,157.61) v2(45.44,163.26) v2(45.9,32.47) v2(45.9,31.7) v2(46.56,25.39) v2(47.18,24.8) v2(47.65,25.39) v2(48.17,24.78) v2(48.72,25.37) v2(49,34.3) v2(49.12,177.44) v2(49.12,176.65) v2(49.12,175.81) v2(49.12,24.73) v2(49.19,179.58) v2(49.38,8.9) v2(49.38,8.07) v2(49.38,7.24) v2(49.38,6.42) v2(49.63,33.66) v2(50.14,8.9) v2(50.14,8.07) v2(50.14,7.24) v2(50.14,6.42) v2(50.84,14.1) v2(51.54,179.71) v2(51.98,160.79) v2(52.15,177.72) v2(52.3,123.51) v2(52.49,158.44) v2(52.62,89.13) v2(52.74,164.22) v2(52.93,161.8) v2(53.06,13.28) v2(53.19,14.04) v2(53.82,158.82) v2(53.82,156.41) v2(53.82,13.28) v2(54.71,13.28) v2(54.87,35.5) v2(55.45,172.36) v2(55.66,34.3) v2(57.25,6.48) v2(57.35,172.31) v2(58.84,68.78) v2(58.84,67.95) v2(58.84,67.19) v2(58.84,66.36) v2(59.51,172.36) v2(59.67,68.01) v2(59.67,67.19) v2(61.65,172.36) v2(62.13,108.64) v2(62.13,107.85) v2(63.25,131.46) v2(63.28,80.27) v2(63.37,136.24) v2(63.4,134.97) v2(63.88,171.72) v2(63.88,142.54) v2(63.91,123.51) v2(64.21,119.14) v2(64.31,140.45) v2(64.31,139.11) v2(64.26,127.2) v2(64.31,122.04) v2(64.41,130.04) v2(64.49,75.51) v2(64.81,79) v2(64.81,77.73) v2(65.18,135.17) v2(65.46,130.98) v2(65.57,88.72) v2(65.7,76.21) v2(65.7,75.19) v2(65.91,135.12) v2(65.89,132.38) v2(65.89,124.3) v2(66.14,137.43) v2(66.22,142.41) v2(66.37,139.16) v2(66.52,119.58) v2(66.57,172.2) v2(66.61,121.53) v2(66.7,129.74) v2(66.68,127.12) v2(66.75,125.42) v2(66.76,70.63) v2(67.16,64.59) v2(67.39,145.4) v2(67.52,70.63) v2(67.64,137.33) v2(67.74,135.76) v2(67.74,134.46) v2(67.74,118.97) v2(67.84,173) v2(67.78,142.97) v2(68.05,131.49) v2(68.06,71.98) v2(68.06,71.22) v2(68.17,141.39) v2(68.22,139.41) v2(68.5,128.52) v2(68.91,124.66) v2(68.99,122.27) v2(69.24,118.66) v2(69.75,145.31) v2(70.23,173.14) v2(70.18,132.45) v2(70.32,145.85) v2(70.32,142.82) v2(70.33,111.07) v2(70.36,139.92) v2(70.46,67.82) v2(70.52,31.95) v2(70.59,30.17) v2(70.56,27.74) v2(70.71,127.63) v2(70.84,144.23) v2(70.97,173.89) v2(71.04,125.14) v2(71.15,121.71) v2(71.1,111.07) v2(71.17,118) v2(71.48,112.21) v2(71.82,31.97) v2(71.86,85.73) v2(71.86,81.29) v2(71.86,77.79) v2(71.86,73.6) v2(71.86,70.87) v2(72.05,30.1) v2(72.31,139.92) v2(72.29,117.09) v2(72.43,27.82) v2(72.49,148.85) v2(72.72,145.89) v2(72.92,116.6) v2(72.99,175.32) v2(73.15,173.91) v2(73.33,144.25) v2(73.64,133.98) v2(73.69,146.84) v2(73.66,133.19) v2(74.08,90.18) v2(74.42,133.98) v2(74.42,133.19) v2(74.45,132.43) v2(74.84,148.85) v2(74.91,175.46) v2(74.97,102.75) v2(75.81,147.16) v2(76.3,102.75) v2(77.5,136.7) v2(77.57,93.6) v2(77.76,104.15) v2(78.05,137.18) v2(79.22,120.95) v2(79.22,104.21) v2(80.01,120.97) v2(80.49,104.21) v2(80.57,135.35) v2(80.57,134.61) v2(80.87,96.91) v2(81.2,127.32) v2(81.33,134.61) v2(81.38,135.35) v2(81.83,104.21) v2(82.04,127.3) v2(82.14,135.35) v2(82.98,127.32) v2(82.97,98.94) v2(83.1,102.69) v2(83.22,105.03) v2(83.74,127.32) v2(84.3,208.73) v2(84.3,206.19) v2(84.3,203.78) v2(84.43,189.87) v2(84.37,186.7) v2(84.81,105.16) v2(84.89,127.32) v2(85.13,186.7) v2(85.12,181.93) v2(85.19,189.87) v2(85.32,190.66) v2(85.26,101.22) v2(85.65,127.32) v2(86.91,182.25) v2(87.1,183.84) v2(87.1,104.91) v2(87.35,103.32) v2(87.99,208.6) v2(88.05,17.4) v2(87.99,15.82) v2(88.11,206.32) v2(88.11,203.78) v2(88.3,167.39) v2(88.68,183.84) v2(88.81,18.23) v2(88.81,17.4) v2(88.81,15.82) v2(89.32,186.25) v2(89.57,183.71) v2(89.57,105.54) v2(90.72,162.95) v2(91.03,185.11) v2(91.22,107.19) v2(91.31,175.46) v2(91.42,160.6) v2(91.8,208.6) v2(91.8,206.32) v2(91.8,203.78) v2(92.1,182.67) v2(93.13,186.25) v2(93.57,161.68) v2(93.62,109.56) v2(94.4,182.25) v2(94.84,161.68) v2(94.91,160.03) v2(95.73,208.48) v2(95.73,206.32) v2(95.73,203.78) v2(96.24,159.96) v2(96.37,182.11) v2(96.88,159.14) v2(97.26,28.39) v2(97.89,33.47) v2(98.21,159.07) v2(98.27,154.88) v2(98.84,33.47) v2(98.9,164.99) v2(98.91,164.22) v2(98.91,163.45) v2(98.91,162.69) v2(99.29,208.35) v2(99.42,206.06) v2(99.42,203.78) v2(99.54,154.88) v2(99.66,164.99) v2(99.67,164.22) v2(99.67,163.45) v2(99.67,162.69) v2(101.38,208.86) v2(101.51,204.67) v2(102.34,147.01) v2(102.85,33.47) v2(103.89,189.45) v2(104.18,145.8) v2(105.19,167.07) v2(105.32,204.73) v2(105.26,159.64) v2(105.7,144.28) v2(105.96,208.86) v2(106.02,167.07) v2(106.02,166.31) v2(106.02,165.55) v2(106.02,164.79) v2(106.02,159.64) v2(106.27,189.49) v2(106.78,159.64) v2(107.54,159.64) v2(109.2,70.81) v2(109.2,70.05) v2(109.2,69.28) v2(109.98,189.49) v2(110.02,159.64) v2(110.78,159.64) v2(110.97,208.98) v2(112.36,189.49) v2(112.62,152.02) v2(112.62,149.48) v2(112.88,32.45) v2(113.45,152.02) v2(113.45,149.48) v2(113.83,33.47) v2(115.04,208.92) v2(115.16,162.57) v2(115.16,161.8) v2(115.16,161.04) v2(115.16,160.28) v2(115.16,153.93) v2(115.16,153.17) v2(115.16,152.41) v2(115.16,151.64) v2(115.93,162.57) v2(115.93,161.8) v2(115.93,161.04) v2(115.93,160.28) v2(115.93,153.93) v2(115.93,153.17) v2(115.93,152.41) v2(115.93,151.64) v2(116.37,165.93) v2(117.64,117.16) v2(117.64,116.34) v2(117.64,115.51) v2(117.64,114.62) v2(117.64,113.73) v2(117.64,112.91) v2(117.83,111.89) v2(117.83,110.88) v2(117.83,109.86) v2(117.83,108.78) v2(123.61,21.28) v2(125.83,20.64) v2(126.59,20.64) v2(127.36,20.64) v2(128.56,31.88) v2(128.56,31.12) v2(129.39,31.88) v2(129.39,31.12) v2(129.52,118.75) v2(129.52,117.99) v2(129.49,117.02) v2(129.49,116.24) v2(129.52,112.34) v2(129.52,111.58) v2(129.52,110.75) v2(129.52,109.92) v2(129.52,109.1) v2(129.52,108.34) v2(130.02,203.08) v2(130.15,208.86) v2(130.21,31.88) v2(130.21,31.12) v2(131.04,31.88) v2(131.04,31.12) v2(131.23,191.59) v2(131.23,189.49) v2(131.36,193.93) v2(131.67,196.16) v2(131.75,69.56) v2(131.75,68.82) v2(131.93,162.18) v2(131.93,161.42) v2(131.93,160.66) v2(131.93,159.9) v2(131.86,73.98) v2(132.25,156.47) v2(132.25,155.14) v2(132.25,153.87) v2(132.25,152.6) v2(132.37,198.32) v2(132.56,193.62) v2(132.56,191.71) v2(132.6,74) v2(132.69,162.18) v2(132.69,161.42) v2(132.69,160.66) v2(132.69,159.9) v2(132.69,155.77) v2(132.69,154.5) v2(132.69,153.23) v2(132.69,151.96) v2(132.82,195.84) v2(132.88,25.85) v2(133.58,25.34) v2(133.77,201.75) v2(134.09,27.56) v2(136.37,166.69) v2(136.88,208.86) v2(136.88,202.95) v2(138.72,166.76) v2(139.55,208.79) v2(139.61,204.35) v2(146.41,208.79) v2(146.41,203.84) v2(147.04,113.86) v2(149.58,113.86) v2(151.23,208.86) v2(151.36,203.84) v2(152.44,113.86) v2(155.68,113.86) v2(156.57,208.86) v2(156.63,204.98) v2(156.95,181.49) v2(156.88,177.55) v2(157.84,112.78) v2(160,110.62) v2(160.47,171.22) v2(162.41,208.86) v2(162.6,108.02) v2(164.76,205.05) v2(169.01,208.86) v2(172.63,101.22) v2(172.7,136.4) v2(172.7,135.64) v2(173.46,154.88) v2(173.46,154.12) v2(173.52,136.4) v2(173.52,135.64) v2(173.46,101.22) v2(173.46,100.4) v2(174.16,100.02) v2(174.28,154.88) v2(174.28,154.12) v2(174.35,136.4) v2(174.35,135.64) v2(174.28,101.22) v2(175.04,100.91) v2(175.04,100.02) v2(175.11,154.88) v2(175.11,154.12) v2(175.17,136.4) v2(175.17,135.64) v2(175.93,154.88) v2(175.93,154.12) v2(175.93,99.95) v2(177.52,208.92) v2(177.58,206.06) v2(179.74,101.22) v2(179.74,99.98) v2(180.19,100.63) v2(180.57,99.98) v2(180.67,101.24) v2(181.2,136.4) v2(181.2,135.64) v2(181.2,100.68) v2(181.27,154.88) v2(181.27,154.12) v2(181.61,99.99) v2(181.74,101.21) v2(182.03,136.4) v2(182.03,135.64) v2(182.09,154.88) v2(182.09,154.12) v2(182.79,136.4) v2(182.79,135.64) v2(182.92,154.88) v2(182.92,154.12) v2(182.86,22.68) v2(183.36,24.07) v2(183.49,208.92) v2(183.62,135.64) v2(183.74,154.88) v2(183.74,154.12) v2(184.38,135.64) v2(186.16,206) v2(187.87,162.88) v2(189.52,208.92) v2(190.09,99.38) v2(190.2,122.83) v2(190.6,162.88) v2(190.6,160.15) v2(190.75,100.3) v2(193.02,206.06) v2(193.14,162.88) v2(195.05,162.88) v2(194.98,160.09) v2(196.06,200.67) v2(196.06,192.73) v2(196.19,208.86) v2(197.65,94.75) v2(197.65,93.8) v2(197.65,92.91) v2(197.65,92.02) v2(198.79,197.36) v2(198.86,203.4) v2(198.86,192.66) v4(5.11,83.79) v4(5.11,81.7) v4(8.3,83.79) v4(8.3,81.7) v4(20.17,32.2) v4(20.17,30.87) v4(20.55,29.98) v4(20.55,27.37) v4(20.55,25.02) v4(21.17,15) v4(21.17,13.21) v4(21.31,28.14) v4(22.26,21.09) v4(23.86,15) v4(23.86,13.21) v4(24.42,20.96) v4(27.72,84.02) v4(29.57,82.56) v4(30.52,84.97) v4(30.65,80.71) v4(30.84,38.65) v4(30.84,37.97) v4(37.25,77.61) v4(37.77,78.12) v4(38.23,100.6) v4(38.99,100.63) v4(40.26,83.48) v4(41.01,86.94) v4(41.22,82.7) v4(41.2,81.7) v4(41.17,80.66) v4(41.79,85.58) v4(41.91,84.65) v4(42.09,80.71) v4(42.19,97.55) v4(42.44,93.71) v4(42.67,94.71) v4(43.24,81.54) v4(43.36,87.93) v4(43.38,85.62) v4(43.61,83.8) v4(44.2,82.2) v4(45.13,85.17) v4(45.3,95.68) v4(46.07,91.89) v4(46.07,91.11) v4(46.07,88.01) v4(46.44,95.4) v4(46.55,82.12) v4(47.59,96.36) v4(47.59,85.08) v4(47.56,82.59) v4(47.57,81.91) v4(48.4,86.46) v4(49.17,90.34) v4(49.17,89.56) v4(49.17,88.79) v4(49.94,90.34) v4(49.94,89.56) v4(49.94,87.24) v4(49.94,86.46) v4(49.97,85.22) v4(49.97,82.12) v4(50.72,90.34) v4(50.72,89.56) v4(50.72,88.79) v4(50.72,88.01) v4(51.04,85.11) v4(51.01,84.4) v4(51.49,91.89) v4(51.47,91.11) v4(52.2,101.36) v4(52.32,97.91) v4(52.3,94.68) v4(52.3,82.24) v4(52.32,81.4) v4(53.28,95.42) v4(53.99,94.69) v4(54.24,84.27) v4(54.45,82.52) v4(54.5,95.27) v4(54.9,83.63) v4(55.07,89.17) v4(55.26,80.73) v4(55.41,96.4) v4(55.68,84.57) v4(55.84,87.99) v4(55.83,86.91) v4(56.06,91.56) v4(56.34,92.67) v4(56.41,97.7) v4(56.39,83.58) v4(56.46,90.39) v4(56.49,84.6) v4(56.79,91.53) v4(56.86,7.65) v4(57.23,93.74) v4(57.2,84.6) v4(57.28,90.37) v4(57.35,85.74) v4(57.56,91.48) v4(57.93,93.75) v4(58.01,86.94) v4(57.96,84.63) v4(58.15,9.64) v4(58.4,80.97) v4(58.51,165.31) v4(58.51,163.12) v4(58.63,97.85) v4(59.27,100.66) v4(59.75,78.2) v4(60.14,77.67) v4(60.7,165.31) v4(60.7,163.12) v4(60.68,88.97) v4(61.32,93.35) v4(61.82,88.97) v4(62.34,104.08) v4(62.5,84.6) v4(62.65,91) v4(62.81,82.25) v4(62.89,106.77) v4(62.92,105.63) v4(63.03,88.84) v4(63.28,92.97) v4(64.3,88.8) v4(65.32,95.13) v4(65.51,115.11) v4(92.8,179.72) v4(92.8,177.03) v4(94.6,179.72) v4(94.6,177.03) v4(94.55,121.07) v4(95.42,119.47) v4(97.57,119.32) v4(100.37,133.74) v4(100.39,31.54) v4(100.39,29.05) v4(102.18,132.33) v4(102.38,31.54) v4(102.38,29.05) v4(104.55,133.88) v4(105.32,132.15) v4(106.51,194.36) v4(108.56,102.28) v4(108.7,194.36) v4(117.02,166.69) v4(129.04,93.35) v4(129.46,85.29) v4(129.74,91.11) v4(130.17,88.53) v4(131.37,91.02) v4(131.58,90.21) v4(132.78,89.91) v4(133.06,89.25) v4(167.93,183.27) v4(167.93,181.17) v4(167.93,179.08) v4(170.03,183.27) v4(170.03,179.08) v4(172.12,183.27) v4(172.12,181.17) v4(172.12,179.08) v4(173.58,95.57) v4(177.2,92.14) v4(180.04,62.02) v4(180.76,67.38) v4(181.01,87.57) v4(181.01,82.81) v4(181,80.03) v4(181.01,76.59) v4(181.03,72.81) v6(38.93,83.45) v6(43.05,99.02) v6(43.16,79.34) v6(45.31,99.02) v6(47.6,99.02) v6(49.86,99.02) v6(49.94,80.64) v6(49.96,81.35) v6(52.36,80.52) v6(54.41,99.03) v6(58.63,88.06) v6(58.62,85.8) v6(58.63,83.31) v6(118.39,166.52) v6(137.82,166.52) v6(187.24,139.2) v6(187.94,139.43) v6(187.94,122.22) v6(188.64,99.55) v6(189.33,139.2) v6(189.33,122.09) v7(89.7,127.32) v7(89.92,132.07) v7(91.31,136.44) v7(91.64,132.96) v7(91.92,127.32) v7(92.75,128.34) v7(92.76,133.62) v7(93.55,136.47) v7(94.06,133.67) v7(94.97,127.78) v7(95.35,129.1) v7(95.53,132.89) v7(96.11,136.01) v7(97.45,128.47) v7(97.57,132.21) v7(98.25,135.07) v7(98.53,120.97) v7(99.42,124.28) v7(100.81,120.78) v7(101.51,121.99) v7(101.7,124.28) v7(125.1,117.24) v7(125.1,116.4) v7(125.1,115.23) v7(125.1,114.09) v7(125.1,113.15) v7(125.1,112.08) v7(125.1,111.12) v7(125.1,110.13) v7(125.1,109.24) v7(125.1,108.48)
V2P5U_EN: length 6.9
  TOP w0.254: U29.2 104.97,29.66 C486.2 R500.1 R501.2 v2(108.81,28.8) R502.1
  BOTTOM w0.102: v3(108.81,27.88) v2(108.81,28.8)
VCC3_POK: length 76.8
  TOP w0.102: v2(43.16,156.03) 43.16,151.33 42.65,150.82 30.2,150.82 25.63,155.39 23.11,155.39 v2(22.86,155.14) ; R247.1 R251.1 R257.1 8.8,138.12 8.74,138.18 Q23.D Q22.D v2(6.52,139.77)
  TOP w0.203: U39.4 37.36,159.26 v2(37.12,159.02)
  TOP w0.254: R180.2 36.66,159.02 v2(37.12,159.02)
  BOTTOM w0.102: v2(22.86,155.14) 22.81,155.09 22.81,154.58 22.1,153.87 21.16,153.87 19.25,155.77 15.72,155.77 14.95,155 14.95,153.6 14.38,153.03 13.82,153.03 5.69,144.9 5.69,141.98 v3(6.58,141.09) 6.52,141.03 v2(6.52,139.77) ; v2(43.16,156.03) 41.89,156.03 41.36,156.55 41.36,157.76 41.81,158.21 41.81,159.58 41.53,159.86 37.66,159.86 37.12,159.33 v2(37.12,159.02)
VCC_BG: length 10.6
  TOP w0.305: R602.2 54.46,6.8 55.09,7.44 v2(55.09,7.82) 55.42,8.14 U38.4
  TOP w0.508: QD5L1.G 48.87,10.48 49.28,10.07 C589.1 v2(50.33,10.07)
  BOTTOM w0.508: v2(50.33,10.07) 51.49,10.07 v3(51.92,9.64) 53.75,7.82 v2(55.09,7.82)
VCC_BST: length 1.9
  TOP w0.305: 55.33,9.91 55.6,9.64 U38.1
  TOP w0.508: R583.1 54.7,10.55 55.33,9.91
VCC_EN: length 10.5
  TOP w0.254: U38.7 60.14,8.14 C600.2 61.46,9.47 C598.2 61.86,9.18 62.33,8.71 63.22,8.71 63.98,7.94 64.24,7.94 64.63,7.55 Q86.6 65.87,7.55 66.27,7.94 66.27,8.58 66.54,8.85 Q86.3
VCC_FB: length 9.5
  TOP w0.254: U38.8 59.68,8.64 C600.1 61.65,10.61 R623.1 61.86,13.21 R571.2 R584.1 R587.1
VCC_PHASE: length 13.3
  TOP w0.305: U38.2 55.39,9.14 55.26,9.28 v2(54.14,9.28)
  TOP w0.508: v2(54.14,9.28) 53.95,9.09 53.95,8.55 54.3,8.2 C587.2
  BOTTOM w0.508: v2(45.63,12.13) 51.28,12.13 v2(54.14,9.28)
  vias: v2(36.87,9.85) v2(37.06,7.24) v2(37.06,4.83) v2(38.2,9.47) v2(39.41,10.36) v2(39.6,11.5) v2(41.25,11.18) v2(41.25,8.77) v2(41.25,5.91) v2(43.92,12.13) v2(44.87,4.7)
VCC_POK: length 267.1
  TOP w0.102: v2(63.7,2.41) v2(63.7,5.12) ; v2(12.17,157.87) 13.1,157.87 13.73,158.49 14.82,158.49 15.82,159.49 19.2,159.49 20.32,160.62 21.35,160.62 21.96,161.23 30.9,161.23 31.41,160.72 32.08,160.72 32.61,161.26 32.61,161.84 R200.2
  TOP w0.254: v2(57.51,10.61) 58.52,10.61 58.97,10.17 U38.10
  BOTTOM w0.102: v2(63.7,2.41) 62.62,1.32 3.74,1.32 1.6,3.46 1.6,54.55 9.78,62.73 9.78,65.89 9.09,66.59 9.09,69.09 9.98,69.99 9.98,70.77 10.36,71.15 10.36,71.71 10.03,72.04 9.28,72.04 7.33,74 7.33,76.88 7.28,76.93 3.68,80.53 3.68,148.11 7.99,152.42 10.55,152.42 11.77,153.65 11.77,157.47 v2(12.17,157.87) ; v2(57.51,10.61) 58.01,10.61 62.43,6.19 v3(62.64,6.19) v2(63.7,5.12)
VCC_TG: length 7.5
  TOP w0.305: v2(54.81,8.68) 54.85,8.64 U38.3
  TOP w0.508: R569.1 v2(52.3,12.58)
  BOTTOM w0.508: v2(52.3,12.58) 52.49,12.58 55.09,9.98 55.09,8.96 v2(54.81,8.68)
VCC_VCC: length 15.3
  TOP w0.508: C586.2 v2(59.97,6.48) 60.06,6.57 R608.2 R622.2 ; D27.P 52.19,4.78 v2(53.06,5.66)
  BOTTOM w0.508: v2(53.06,5.66) 53.06,4.39 53.78,3.67 56.53,3.67 59.35,6.48 v2(59.97,6.48)
VCCIO_EN: length 413.8
  TOP w0.102: v2(135.8,9.47) 135.99,9.66 135.99,13.79 135.23,14.55 135.23,16.46 136.38,17.61 138.93,17.61 139.85,18.52 146.22,18.52 147.45,19.75 147.45,21.41 146.66,22.19 146.66,25.85 146.22,26.29 146.22,31.88 147.01,32.68 R478.2 ; U22.6 76.85,136.96 77.6,137.71 77.6,148.13 75.07,150.65 68.42,150.65 66.95,152.12 65.2,152.12 62.31,149.23 54.46,149.23 52.2,146.97 34.48,146.97 32.93,145.42 28.59,145.42 24.59,149.42 23.57,149.42 v2(23.29,149.7) ; R247.2 10.31,140.99 v2(9.27,140.99) ; v2(8.8,130.37) Q25.C
  BOTTOM w0.102: v2(23.29,149.7) 23.29,148.8 21.05,146.56 20.1,146.56 19.09,145.55 15.53,145.55 14.71,144.72 11.79,144.72 9.27,142.21 v2(9.27,140.99) 9.8,140.45 9.8,136.59 9.14,135.93 9.14,130.71 v2(8.8,130.37) 8.51,130.08 8.51,118.31 9.02,117.8 9.02,113.5 8.53,113.02 8.53,102.32 8.03,101.81 8.03,95.71 7.35,95.04 7.35,86.71 8.74,85.32 8.74,80.71 9.42,80.02 10.46,80.02 12.1,78.38 12.1,77.64 12.32,77.43 12.81,76.94 13.54,76.94 14.03,76.45 14.03,75.7 14.45,75.28 14.45,69.75 13.69,68.99 13.69,67 13.15,66.46 13.15,61.87 11.25,59.98 11.25,56.71 10.49,55.95 10.49,53.04 6.3,48.85 6.3,37.77 4.39,35.87 4.39,11.32 6.52,9.2 12.09,9.2 12.8,8.49 16.96,8.49 18.14,7.31 20.08,7.31 20.84,7.31 22.76,9.23 26.16,9.23 26.53,8.85 27.12,8.26 30.15,8.26 35.7,13.81 42.18,13.81 43.68,15.31 54.97,15.31 57.51,12.77 58.7,12.77 59.21,12.26 59.21,11.07 61.28,8.99 62.68,8.99 63.6,8.07 65.25,8.07 v3(65.63,8.45) 66.52,8.45 67.98,6.99 96.9,6.99 98.62,8.72 118.94,8.72 119.4,8.26 130.48,8.26 131.18,8.96 135.29,8.96 v2(135.8,9.47)
VCCIO_PWRGD: length 3.3
  TOP w0.203: R252.2 C232.2 76.05,137.07 U22.8
VCCIO_SENSE: length 90.5
  TOP w0.102: v2(75.49,111.19) 77.67,111.19 78.99,112.52 78.99,117.61 81.61,120.23 81.61,124.15 82.85,125.39 86.28,125.39 88.93,128.03 88.93,134.71 90.07,135.86 90.07,137.72 92,139.65 v2(92,140.03) ; SP10.1 81.89,141.48 v2(82.65,140.72) ; v2(87.1,106.62) 87.67,106.05 88.94,106.05 89.32,106.43 89.32,106.43 93.3,110.41 97.97,110.41 98,110.43 101.46,110.43 103.34,108.55 104.11,108.55 104.15,108.59 106.62,108.59 107.19,109.16 CPU.AF4
  BOTTOM w0.102: v2(82.65,140.72) 83.73,140.72 v3(83.77,140.76) 84.13,141.12 91.33,141.12 92,140.45 v2(92,140.03) ; v2(75.49,111.19) 75.34,111.19 74.35,110.2 74.35,108.39 75.79,106.94 86.78,106.94 v2(87.1,106.62)
VCCST_PWRGD: length 167.3
  TOP w0.102: v2(32.6,147.86) 32.6,147.66 32.11,147.17 29.97,147.17 25.51,151.63 22.5,151.63 21.36,152.77 19.94,152.77 18.69,151.53 18.24,151.53 18.01,151.3 17.12,151.3 16.94,151.48 16.64,151.48 15.42,152.7 13.67,152.7 12.23,151.26 12.23,141.61 v2(11.98,141.36) ; v2(44.35,119.72) 46.3,121.67 52.41,121.67 54.1,123.36 57.34,123.36 63.79,116.91 70.99,116.91 73.56,114.34 73.56,110.13 74.95,108.74 76.61,108.74 79.68,111.81 79.68,117.26 82.42,120 82.42,123.39 82.8,123.77 R281.1 ; R303.2 6.17,111.13 R317.2 6.71,111.04 7.09,111.42 10.19,111.42 v2(10.77,110.84)
  BOTTOM w0.102: v2(44.35,119.72) 33.93,130.13 33.93,146.53 v2(32.6,147.86) ; v2(10.77,110.84) 12.01,112.09 12.01,118.89 v3(11.38,119.53) 10.77,120.13 10.77,122.56 11.63,123.42 11.63,141.01 v2(11.98,141.36)
VCCST_PWRGD_CPU: length 25.2
  TOP w0.102: R283.1 84.52,123.13 R281.2 86.53,122.4 91.72,122.4 95.91,118.2 101.91,118.2 102.31,117.8 104.6,117.8 105,117.39 CPU.U2
VCCTG: length 3.8
  TOP w0.508: R569.2 49.04,12.58 v1(48.46,12.01) 47.7,12.01 R570.1 47.6,12.17 QD5H1.G
VDDQ_C1: length 5.6
  TOP w0.254: R470.1 144.41,33.69 144.95,33.15 Q47.G 144.95,31.76 v2(144.5,31.31) Q46.D
  BOTTOM w0.102: v2(144.5,31.31) 145.11,31.92 v3(145.11,32.02)
VDDQ_C2: length 3.6
  TOP w0.102: R479.1 149.64,31.43 v1(149.12,30.9)
  TOP w0.254: R479.1 R478.1 148.15,31.31 Q47.D
