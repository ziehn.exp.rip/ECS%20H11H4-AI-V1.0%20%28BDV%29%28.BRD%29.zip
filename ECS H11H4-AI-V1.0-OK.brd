# Allegro board ECS H11H4-AI-V1.0-OK.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SYS_THERM: length 12.2
  TOP w0.203: U35.87 187.1,26.1 187.23,25.98
  TOP w0.254: 187.23,25.98 188.37,24.83 v1(191.44,24.83) 191.66,24.61 C504.1 C505.2 R523.2 194.48,24.9 193.65,25.72 R516.2
SYS_VSB: length 3.7
  TOP w0.203: 186.87,18.31 186.68,18.31 186.47,18.1 U35.67
  TOP w0.508: R546.1 188.14,18.31 v1(187.63,18.31) 186.87,18.31
TCM_24M: length 204.9
  TOP w0.102: TCM.1 119.36,4.77 C577.2 R593.1 118.23,7.78 117.56,8.45 117.56,11.42 v4(117.58,11.44) ; R365.2 v2(28.17,84.63)
  BOTTOM w0.102: v2(28.17,84.63) 26.98,84.63 25.55,83.2 25.55,80.69 24.59,79.72 24.59,74.95 23.11,73.48 23.11,70.86 21.42,69.17 21.42,65.81 23.08,64.15 23.08,58.85 21.36,57.14 21.36,55.27 20.29,54.2 18.34,54.2 15.71,51.56 15.71,45.2 14.52,44.01 14.52,36.36 12.68,34.52 12.68,19.36 13.56,18.47 13.56,13.47 15.27,11.77 29.91,11.77 34.68,16.54 41.29,16.54 42.6,17.85 56.34,17.85 58.06,16.13 64.68,16.13 66.14,14.67 85.7,14.67 86.64,13.73 90.32,13.73 91.29,12.77 91.29,11.32 92.66,9.94 94.05,9.94 96.36,12.25 117.21,12.25 117.58,11.88 v4(117.58,11.44)
THERMAL_SD: length 253.9
  TOP w0.089: 46.81,71.52 46.81,75.66 47.78,76.63 47.78,78.22 47.78,78.22 47.78,78.52 47.56,78.75 PCH1.AE44
  TOP w0.102: 46.81,71.52 46.81,70.24 R409.1 45.89,69.32 45.89,68.1 44.81,67.02 44.81,66.29 43.33,64.81 v2(43.33,62.3) ; U35.10 170.98,26.1 174.92,22.17 v2(175.62,22.17)
  BOTTOM w0.102: v2(175.62,22.17) v3(174.73,21.28) 174.24,20.8 170.16,20.8 165.57,16.2 150.85,16.2 150.81,16.24 150.81,16.24 149.33,17.71 149.33,17.71 145.21,21.84 141.88,21.84 140.88,20.83 135.68,20.83 133.38,18.53 120.66,18.53 119.9,17.77 112.45,17.77 111.23,18.99 105.68,18.99 104.55,17.86 95.7,17.86 89.59,23.97 55.14,23.97 53.57,22.4 40.84,22.4 40.46,22.78 35.41,22.78 33.83,21.19 30.79,21.19 28.26,18.66 20.24,18.66 17.76,21.15 17.76,33.13 21.54,36.92 21.54,39.86 22.26,40.58 22.26,44.31 21.48,45.09 21.48,48.18 25.77,52.47 29.03,52.47 33.18,56.62 37.43,56.62 43.1,62.3 v2(43.33,62.3)
TP_CPU_K12: length 3.3
  TOP w0.089: v4(114.08,124.28) 114.47,123.89 114.47,123.83 CPU.K12
  BOTTOM w0.089: v4(114.08,124.28) 115.14,124.28 STP3.1
TP_CPU_L12: length 3
  TOP w0.102: v4(114.08,123.32) 114.08,123.3 CPU.L12
  BOTTOM w0.089: STP4.1 113.25,123.32 v4(114.08,123.32)
TP_FAN_CTL4: length 2.5
  TOP w0.102: U35.118 175.64,29.95 v2(175.81,29.79)
  BOTTOM w0.102: v2(175.81,29.79) 176.21,30.19 STP31.1
TP_PCH_AB13: length 3.7
  TOP w0.089: PCH1.AB13 49.83,94.69 v4(50.18,94.69)
  BOTTOM w0.089: v4(50.18,94.69) 50.6,95.11 50.6,95.83 51.49,96.72 STP9.1
TP_PWMOUT: length 5.9
  TOP w0.102: U35.15 v1(168.58,24.1) 167.73,23.25 165.42,23.25 R526.2
TP_SPI1_CLK: length 1.7
  TOP w0.089: v4(43.35,83.19) 43.69,82.85 PCH1.AN36
  BOTTOM w0.089: v4(43.35,83.19) 43.16,83.38 STP19.1
TP_SPI1_CS_N: length 3.4
  TOP w0.089: v4(44.17,81.56) 44.68,81.08 PCH1.AL39
  BOTTOM w0.089: v4(44.17,81.56) 43.95,81.56 STP23.1
TP_SPI1_IO2: length 10.5
  TOP w0.089: PCH1.AG44 46.9,78.63
  TOP w0.102: 46.9,78.63 46.93,78.59 46.93,76.57 45.82,75.46 45.82,70.49 v2(45.38,70.05)
  BOTTOM w0.102: v2(45.38,70.05) 45.19,69.86 STP29.1
TP_SPI1_IO3: length 4
  TOP w0.089: PCH1.AH43 46.41,79.31 46.63,79.08 46.63,78.61 46.74,78.51 46.74,77.13 v7(46.33,76.73)
  BOTTOM w0.102: v7(46.33,76.73) 46.86,76.19 STP27.1
TP_SPI1_MISO: length 1.8
  TOP w0.089: v4(43.26,82.32) 43.64,81.94 PCH1.AN38
  BOTTOM w0.089: STP21.1 42.54,81.6 v4(43.26,82.32)
TP_SPI1_MOSI: length 4.2
  TOP w0.089: v4(44.16,80.85) 44.13,80.85 PCH1.AN41
  BOTTOM w0.089: v4(44.16,80.85) 44.11,80.85 42.29,79.04 STP26.1
TP_VGA: length 8.1
  TOP w0.089: PCH1.L44 54.99,78.58 52.87,76.46 v2(52.87,73.41) R396.2
  BOTTOM w0.102: STP_VGA.1 52.78,73.32 v2(52.87,73.41)
TPM_P5: length 6
  TOP w0.102: R594.1 C578.2 121.9,4.39 TCM.5
TPM_P6: length 3
  TOP w0.102: R596.2 R595.2 TCM.6
TPM_P15: length 5.2
  TOP w0.102: R598.1 135.74,7.12 136.63,6.23 136.63,4.26 TCM.15
TPM_P18: length 2.3
  TOP w0.102: TCM.18 137.42,6.64 R607.1
TPM_P19: length 6.4
  TOP w0.102: TCM.19 139.68,4.39 139.68,6.17 140.63,7.12 R600.1 R599.1
TPM_RSV2: length 21
  TOP w0.102: v2(124.12,5.66) 124.12,5.69 R597.2
  BOTTOM w0.102: v2(124.12,5.66) 124.12,5.67 125.16,6.71 131.12,6.71 131.82,7.41 139.19,7.41 TCM.20
TS_D-: length 7.2
  TOP w0.203: 187.2,24.21 186.51,24.9 U35.84
  TOP w0.254: 187.2,24.21 188.11,23.3 188.11,23.04 188.61,22.53 190.46,22.53 191.11,23.18 SP20.1
UGND: length 23.8
  TOP w0.508: v2(67.39,184.09) 67.39,181.59 C96.1 ; C97.2 R108.1 78.18,180.57 77.6,181.14 C91.2 77.6,183.81 v2(77.25,184.16) ; C94.1 v2(72.01,184.09) ; U11.2 v2(69.84,184.09) ; U12.2 v2(74.11,184.09) ; v2(64.88,184.09) 64.88,183.03 64.21,182.35 C90.1 63.22,180.63 C95.2 63.09,180.22 64.3,179.01 C102.2 65.09,178.95 C104.2
  vias: v2(61.95,193.62) v2(62.08,208.73) v2(62.08,205.94) v2(62.21,200.86) v2(65.25,208.73) v2(65.25,206.06) v2(65.25,203.4) v2(68.3,200.35) v2(68.43,208.73) v2(68.43,206.06) v2(68.43,203.27) v2(72.11,208.73) v2(72.11,206.19) v2(72.11,200.35) v2(72.24,203.27) v2(75.92,203.4) v2(75.92,200.35) v2(76.05,208.73) v2(76.05,206.19) v2(78.08,197.81) v2(80.49,208.73) v2(80.49,206.19) v2(80.75,193.49) v2(81.95,188.41) v2(83.16,189.93)
UP1740P_FB: length 6.7
  TOP w0.203: R510.2 135.01,26.99 133.9,26.99 133.54,27.35 U32.3
  TOP w0.254: R510.2 135.63,27.62 137.18,27.62 137.74,27.06 C492.1 R504.1
UP1740P_P1: length 3.3
  TOP w0.102: C496.2 v1(135.07,25.04)
  TOP w0.203: C496.2 133.96,25.91 133.33,26.55 U32.1
UP1740P_P2: length 5.3
  TOP w0.203: R514.1 137.33,26.45 v1(134.15,26.45) 133.93,26.45 133.44,26.95 U32.2
UP1740P_P7: length 2.8
  TOP w0.203: U32.7 133.53,28.95 134.16,29.58 v1(134.16,29.63) 135.01,30.49 R486.1
UP1740P_P9: length 4.8
  TOP w0.102: R477.1 v2(135.23,33.06)
  TOP w0.508: R477.1 134.82,32.2 C467.2 133.01,32.3 R481.2
  BOTTOM w0.102: v3(136.09,33.06) v2(135.23,33.06)
UP1740P_P10: length 5
  TOP w0.203: R481.1 132.16,31.34 v1(131.98,31.16) 131.85,31.03 U32.10
  TOP w0.254: v1(131.98,31.16) 131.98,32.79 C597.1
UP1740P_P13: length 14
  TOP w0.508: R486.2 v2(136.94,30.49)
  BOTTOM w0.508: v2(126.78,25.41) 128.05,26.68 134.53,26.68 135.43,27.58 v3(135.43,28.54) 135.43,28.97 v2(136.94,30.49)
UP1740P_P14: length 4.3
  TOP w0.203: U32.14 129.45,25.22 129.18,24.95 129.18,24.76
  TOP w0.508: 129.18,24.76 v1(129.18,23.59) 129.18,23.36 128.56,22.74 C524.1
UP1740P_P16: length 3.8
  TOP w0.203: U32.16 130.25,25.11 v1(129.85,24.71)
  TOP w0.508: v1(129.85,24.71) 129.85,22.6 R535.1
UP1740P_P16_1: length 1.7
  TOP w0.508: C524.2 128.98,20.58 R535.2
UP1740P_PHASE_S: length 1.5
  TOP w0.508: C465.2 126.88,31.76 127.04,31.6 R489.1
UP1740P_VTTIN: length 6.6
  TOP w0.102: v1(133.07,22.7) 132.72,22.35 R532.1
  TOP w0.203: U32.17 130.65,24.44 130.53,24.33
  TOP w0.508: R532.1 132.69,21.82 C525.2 131.17,22.26 131.17,22.96 130.53,23.6 130.53,23.61 130.53,24.33
USB2_COMP: length 8.8
  TOP w0.102: R324.1 49.42,105.43 48.68,105.43 47.28,104.03 47.28,101.83 47,101.55 47,99.83 46.89,99.72 46.89,99.31 46.6,99.03 PCH1.AG3
USB2_ID: length 7.4
  TOP w0.102: R323.1 48.81,105.86 47,104.06 47,102.16 46.74,101.89 46.74,99.85 46.69,99.8 46.69,99.8 46.6,99.72 PCH1.AG2
USB2_VBUSSENSE: length 13
  TOP w0.089: PCH1.AD10 47.72,95.83 v4(47.57,95.73) ; v4(51.41,102.81) 51.61,103.02 51.61,105.05 50.97,105.69
  TOP w0.102: R325.1 50.97,105.69 50.97,105.69
  BOTTOM w0.102: v4(51.41,102.81) 51.41,102.15 50.01,100.75 v3(49.4,100.75) 48.02,99.37 48.02,96.18 v4(47.57,95.73)
USB3_RX_N1: length 118.3
  TOP w0.102: v7(23.86,21.46) 23.53,21.13 23.53,20.71 22.45,19.63 20.08,19.63 19.53,20.17 17.76,20.17 17.46,19.87 RN14.1 ; v2(66.47,76.04) 66.72,75.79 67.66,75.79 68.68,76.81 68.68,93.63 65.17,97.15 60.92,97.15 60.59,96.82 59.46,96.82 59.16,97.12 PCH1.B7
  BOTTOM w0.102: v2(66.47,76.04) 66.72,75.79 67.01,75.79 67.35,75.44 67.35,74.55 64.06,71.27 64.06,68.95 57.78,62.67 55.49,62.67 43.66,50.84 43.66,41.6 39.41,37.34 32.49,37.34 28.11,32.96 28.11,28.83 23.53,24.26 23.53,21.79 v7(23.86,21.46)
USB3_RX_N1_R: length 13.1
  TOP w0.102: RN14.2 14.31,19.87 14.01,20.17 13.25,20.17 13.1,20.02 U36.6 U36.5 11.6,20.02 11.45,20.17 11.28,20.17 10.85,19.74 10.85,16.37 9.4,14.92 7.56,14.92 USB3F.2
USB3_RX_N2: length 116
  TOP w0.102: v2(64.07,76.21) 64.41,76.55 64.41,76.83 64.75,77.16 66.62,77.16 67.98,78.53 67.98,93.32 64.85,96.45 61.69,96.45 61.53,96.28 59.44,96.28 59.35,96.19 59.03,96.19 58.71,96.52 PCH1.C8 ; RN14.5 17.46,21.49 17.76,21.8 18.45,21.8 18.64,21.61 21.11,21.61 v7(21.44,21.28)
  BOTTOM w0.102: v7(21.44,21.28) 21.74,21.58 22.06,21.58 22.78,22.31 22.78,25.12 27.41,29.74 27.41,33.25 32.2,38.04 39.03,38.04 42.96,41.98 42.96,51.15 57.49,65.68 57.49,72.81 59.58,74.91 61.04,74.91 63.2,77.06 64.16,77.06 64.41,76.8 64.41,76.55 v2(64.07,76.21)
USB3_RX_N2_R: length 11.1
  TOP w0.102: USB3F.18 8.66,16.59 8.99,16.92 9.46,16.92 9.96,17.42 9.96,20.48 11.15,21.67 11.46,21.67 11.6,21.52 U36.2 U36.9 13.18,21.52 13.32,21.67 13.67,21.67 13.79,21.79 14.2,21.79 14.49,21.49 RN14.6
USB3_RX_N3: length 146.1
  TOP w0.102: PCH1.B10 59.32,95.9 59.49,95.73 64.05,95.73 64.21,95.56 64.21,95.26 64.08,95.13 v4(63.89,95.13) ; v7(89.56,185.44) 89.56,185.08 89.69,184.96 90.06,184.96 90.27,185.16 90.27,186.2 89.94,186.52 RN6.1
  BOTTOM w0.102: v7(89.56,185.44) 89.69,185.31 89.69,185.11 89.54,184.96 89,184.96 88.62,185.33 88.62,187.2 89.45,188.03 94.97,188.03 97.18,185.82 97.18,181.43 96.31,180.56 91.94,180.56 85.44,174.06 85.44,169.7 78.19,162.45 74.52,162.45 70.26,158.2 66.69,158.2 49.81,141.32 49.81,121.37 60.92,110.26 60.92,102.79 62.38,101.33 62.38,97.9 64.24,96.05 64.24,95.32 64.05,95.13 v4(63.89,95.13)
USB3_RX_N3_R: length 8.2
  TOP w0.102: RN6.2 89.94,189.29 90.27,189.62 90.27,190.25 90.1,190.43 U6.1 U6.10 90.1,191.92 90.27,192.09 90.27,192.97 89.88,193.36 88.89,193.36 88.63,193.63 88.63,194.68 88.5,194.8 USB3X2.14
USB3_RX_N4: length 127.8
  TOP w0.102: RN6.5 91.57,186.67 91.82,186.42 91.82,186.09 v7(91.54,185.81) ; PCH1.E11 57.67,95.35 57.67,95.12 v4(57.34,94.79)
  BOTTOM w0.102: v4(57.34,94.79) 57.34,95.2 58.34,96.2 59.4,96.2 60.5,97.3 60.5,100.45 59,101.95 59,109.47 47.92,120.55 47.92,142.09 65.92,160.09 69.48,160.09 73.71,164.32 77.29,164.32 83.58,170.61 83.58,175.04 93.83,185.29 93.83,186.63 93.38,187.08 92.3,187.08 91.77,186.54 91.77,186.04 v7(91.54,185.81)
USB3_RX_N4_R: length 11.4
  TOP w0.102: USB3X2.5 88.54,198 88.75,197.8 88.75,197.4 89.56,196.58 89.56,196.2 90.83,194.93 90.83,193.91 91.78,192.97 91.78,192.08 91.6,191.89 U6.7 U6.4 91.6,190.45 91.8,190.25 91.8,189.55 91.57,189.32 RN6.6
USB3_RX_P1: length 118.3
  TOP w0.102: v2(23,21.46) 23.21,21.46 23.33,21.34 23.33,20.79 22.37,19.83 20.16,19.83 19.62,20.38 17.76,20.38 17.46,20.68 RN14.3 ; PCH1.A7 59.65,97.02 60.51,97.02 60.84,97.35 65.25,97.35 68.89,93.72 68.89,76.73 67.74,75.58 66.68,75.58 66.47,75.38 v7(66.47,75.18)
  BOTTOM w0.102: v7(66.47,75.18) 66.47,75.43 66.62,75.58 66.92,75.58 67.15,75.36 67.15,74.64 63.86,71.35 63.86,69.03 57.7,62.87 55.41,62.87 43.46,50.92 43.46,41.68 39.32,37.55 32.4,37.55 27.9,33.05 27.9,28.92 23.33,24.35 23.33,21.58 23.21,21.46 v2(23,21.46)
USB3_RX_P1_R: length 13.1
  TOP w0.102: RN14.4 14.31,20.68 14.01,20.38 13.25,20.38 13.1,20.52 U36.7 U36.4 11.62,20.52 11.47,20.38 11.19,20.38 10.64,19.82 10.64,16.45 9.32,15.13 7.56,15.13 USB3F.3
USB3_RX_P2: length 116
  TOP w0.102: RN14.7 17.46,22.31 17.76,22 18.54,22 18.73,21.81 21.11,21.81 v2(21.44,22.14) ; v7(64.94,76.21) 64.62,76.52 64.62,76.74 64.83,76.95 66.7,76.95 68.19,78.44 68.19,93.4 64.94,96.65 61.61,96.65 61.44,96.49 59.36,96.49 59.31,96.43 PCH1.B8
  BOTTOM w0.102: v2(21.44,22.14) 21.79,21.79 21.98,21.79 22.58,22.39 22.58,25.2 27.2,29.83 27.2,33.33 32.12,38.25 38.94,38.25 42.76,42.06 42.76,51.24 57.29,65.77 57.29,72.9 59.5,75.11 60.96,75.11 63.11,77.26 64.25,77.26 64.62,76.89 64.62,76.52 v7(64.94,76.21)
USB3_RX_P2_R: length 11.1
  TOP w0.102: RN14.8 14.53,22.31 14.21,21.99 13.7,21.99 13.59,21.88 13.31,21.88 13.16,22.02 U36.10 U36.1 11.55,22.02 11.41,21.88 11.07,21.88 9.75,20.56 9.75,17.51 9.37,17.13 9.02,17.13 8.66,17.48 USB3F.17
USB3_RX_P3: length 146.1
  TOP w0.102: v7(64.66,95.13) 64.41,95.37 64.41,95.65 64.13,95.93 59.69,95.93 PCH1.A9 ; RN6.3 90.75,186.48 90.47,186.2 90.47,185.08 90.15,184.75 89.84,184.75 v2(89.56,184.47)
  BOTTOM w0.102: v7(64.66,95.13) 64.44,95.34 64.44,96.13 62.59,97.99 62.59,101.42 61.13,102.88 61.13,110.34 50.01,121.46 50.01,141.23 66.77,157.99 70.35,157.99 74.6,162.25 78.27,162.25 85.64,169.62 85.64,173.98 92.02,180.36 96.39,180.36 97.38,181.35 97.38,185.9 95.06,188.23 89.36,188.23 88.42,187.29 88.42,185.25 88.91,184.75 89.28,184.75 v2(89.56,184.47)
USB3_RX_P3_R: length 8.2
  TOP w0.102: RN6.4 90.75,189.27 90.48,189.55 90.48,190.32 90.6,190.44 U6.2 U6.9 90.6,191.97 90.48,192.09 90.48,193.06 89.97,193.57 88.98,193.57 88.83,193.72 88.83,194.41 89.22,194.8 USB3X2.15
USB3_RX_P4: length 127.8
  TOP w0.102: PCH1.G11 56.78,94.93 v4(56.57,94.71) ; RN6.7 92.38,186.64 92.02,186.29 92.02,185.97 92.19,185.81 v2(92.43,185.81)
  BOTTOM w0.102: v2(92.43,185.81) 92.19,185.81 91.97,186.02 91.97,186.46 92.39,186.87 93.3,186.87 93.62,186.55 93.62,185.37 83.38,175.13 83.38,170.69 77.21,164.52 73.63,164.52 69.4,160.29 65.84,160.29 47.71,142.17 47.71,120.47 58.8,109.38 58.8,101.86 60.3,100.37 60.3,97.38 59.31,96.4 58.25,96.4 v4(56.57,94.71)
USB3_RX_P4_R: length 11.4
  TOP w0.102: RN6.8 92.38,189.22 92,189.6 92,190.28 92.1,190.38 U6.5 U6.6 92.1,191.97 91.98,192.08 91.98,193.05 91.03,194 91.03,195.01 89.76,196.28 89.76,196.67 88.95,197.48 88.95,197.8 89.15,198 USB3X2.6
USB3_TX_N1: length 109.3
  TOP w0.102: v7(65.56,78.77) 65.89,78.44 66.25,78.44 67.29,79.48 67.29,92.59 65.76,94.11 63.7,94.11 62.61,95.2 59.37,95.2 59.31,95.15 58.91,95.15 PCH1.C11 ; C509.1 20.13,23.94 20.66,23.94 20.91,23.68 20.91,23.53 v2(20.58,23.2)
  BOTTOM w0.102: v7(65.56,78.77) 65.23,78.44 62.95,78.44 60.34,75.84 59.21,75.84 56.6,73.23 56.6,66.1 42.06,51.55 42.06,42.38 38.63,38.94 32.6,38.94 31.98,39.57 30.4,39.57 29.79,38.96 29.79,37.43 26.44,34.08 26.44,30.06 20.91,24.53 20.91,23.53 v2(20.58,23.2)
USB3_TX_N1_C: length 2.4
  TOP w0.102: CHOKE12.1 17.09,23.85 17.41,24.17 17.69,24.17 17.92,23.95 18.29,23.95 C509.2
USB3_TX_N1_R: length 11.3
  TOP w0.102: RN13.2 14.44,23.95 14.14,24.25 13.25,24.25 13.15,24.15 U34.6 U34.5 11.62,24.15 11.47,24.3 10.9,24.3 10.66,24.05 10.66,22.31 9.27,20.92 7.56,20.92 USB3F.5
USB3_TX_N2: length 103.9
  TOP w0.102: C498.1 20.03,26 20.48,26 v7(20.72,25.77) ; PCH1.B12 59.22,94.77 59.45,95 59.74,95 59.77,94.97 61.03,94.97 61.3,94.7 62.45,94.7 63.53,93.62 65.49,93.62 66.79,92.32 66.79,81.3 65,79.51 64.37,79.51 v2(64.04,79.18)
  BOTTOM w0.102: v2(64.04,79.18) 63.77,79.44 63.22,79.44 60.12,76.35 59,76.35 56.12,73.47 56.12,66.34 41.57,51.79 41.57,42.68 38.33,39.44 32.83,39.44 32.15,40.12 30.16,40.12 29.24,39.2 29.24,37.89 25.88,34.54 25.88,30.23 21.65,26 20.95,26 v7(20.72,25.77)
USB3_TX_N2_C: length 2.5
  TOP w0.102: RN13.5 17.09,25.57 17.4,25.88 17.78,25.88 17.99,26.09 18.31,26.09 C498.2
USB3_TX_N2_R: length 9.7
  TOP w0.102: USB3F.15 8.66,22.6 8.99,22.92 9.52,22.92 9.89,23.3 9.89,25.29 10.4,25.8 11.39,25.8 11.54,25.65 U34.2 U34.9 13.12,25.65 13.25,25.77 13.75,25.77 13.88,25.9 14.14,25.9 14.47,25.57 RN13.6
USB3_TX_N3: length 127.3
  TOP w0.102: v7(95.08,182.75) 95.29,182.75 95.52,182.97 95.52,183.71 95.34,183.89 95.06,183.89 C79.1 ; PCH1.C13 58.91,94.21 59.05,94.34 60.5,94.34 61.05,93.78 61.93,93.78 62.14,93.57 62.14,93.15 61.96,92.97 v4(61.86,92.97)
  BOTTOM w0.102: v4(61.86,92.97) 61.98,92.97 62.14,93.13 62.14,93.57 61.68,94.03 61.68,101.01 60.24,102.46 60.24,109.95 49.11,121.08 49.11,141.59 66.41,158.9 69.98,158.9 74.22,163.14 77.86,163.14 84.75,170.03 84.75,174.36 91.75,181.35 94.77,181.35 95.43,182.01 95.43,182.57 95.25,182.75 v7(95.08,182.75)
USB3_TX_N3_C: length 2.8
  TOP w0.102: C79.2 94.97,185.01 95.41,185.45 95.41,185.79 95.7,186.08 95.7,186.28 95.37,186.61 CHOKE8.1
USB3_TX_N3_R: length 7.3
  TOP w0.102: USB3X2.17 94.61,194.8 94.81,194.61 94.81,193.68 95.61,192.89 95.61,192.09 95.47,191.96 U7.7 U7.4 95.47,190.39 95.61,190.25 95.61,189.62 95.38,189.39 RN7.6
USB3_TX_N4: length 122.9
  TOP w0.102: v7(92.91,182.75) 93.12,182.75 93.35,182.98 93.35,183.46 93,183.82 C78.1 ; v4(59.96,92.98) 60.09,92.98 60.24,93.12 60.24,93.66 60.05,93.85 59.67,93.85 59.6,93.78 PCH1.A14
  BOTTOM w0.102: v4(59.96,92.98) 60.09,92.98 60.24,93.12 60.24,96.05 60.99,96.8 60.99,100.7 59.49,102.19 59.49,109.69 48.41,120.76 48.41,141.89 66.13,159.61 69.7,159.61 73.91,163.82 77.53,163.82 84.07,170.36 84.07,174.76 91.39,182.09 93.07,182.09 93.24,182.26 93.24,182.59 93.09,182.75 v7(92.91,182.75)
USB3_TX_N4_C: length 3.1
  TOP w0.102: C78.2 93.24,185.21 93.24,185.45 94.06,186.27 94.06,186.37 93.75,186.67 RN7.1
USB3_TX_N4_R: length 11.6
  TOP w0.102: USB3X2.8 94.54,198 94.75,197.8 94.75,197.57 94.01,196.83 94.01,196.37 92.74,195.1 92.74,194.1 94.12,192.72 94.12,192.15 93.97,192 U7.10 U7.1 93.97,190.3 94.08,190.19 94.08,189.62 93.75,189.29 RN7.2
USB3_TX_P1: length 109.3
  TOP w0.102: v7(21.44,23.2) 21.11,23.53 21.11,23.77 20.74,24.14 20.13,24.14 C500.1 ; v2(65.56,77.91) 65.89,78.24 66.33,78.24 67.49,79.39 67.49,92.67 65.85,94.32 63.78,94.32 62.69,95.41 59.28,95.41 59.26,95.39 PCH1.B11
  BOTTOM w0.102: v7(21.44,23.2) 21.11,23.53 21.11,24.44 26.65,29.98 26.65,34 30,37.35 30,38.88 30.48,39.36 31.89,39.36 32.52,38.74 38.71,38.74 42.27,42.3 42.27,51.47 56.81,66.01 56.81,73.14 59.3,75.63 60.43,75.63 63.03,78.24 65.23,78.24 v2(65.56,77.91)
USB3_TX_P1_C: length 2.4
  TOP w0.102: C500.2 18.31,24.15 18,24.15 17.78,24.38 17.45,24.38 17.13,24.7 CHOKE12.4
USB3_TX_P1_R: length 11.4
  TOP w0.102: RN13.4 14.44,24.76 14.14,24.45 13.31,24.45 13.11,24.65 U34.7 U34.4 11.6,24.65 11.46,24.5 10.82,24.5 10.45,24.14 10.45,22.39 9.19,21.13 7.56,21.13 USB3F.6
USB3_TX_P2: length 103.9
  TOP w0.102: v7(64.04,80.04) 64.04,79.81 64.14,79.71 64.91,79.71 66.59,81.38 66.59,92.24 65.41,93.41 63.44,93.41 62.36,94.49 61.22,94.49 60.94,94.77 PCH1.A12 ; v2(20.72,26.63) 20.72,26.35 20.57,26.21 19.74,26.21 19.56,26.38 19.56,26.61 C493.1
  BOTTOM w0.102: v2(20.72,26.63) 20.72,26.37 20.88,26.21 21.57,26.21 25.68,30.32 25.68,34.62 29.03,37.97 29.03,39.29 30.07,40.33 32.23,40.33 32.92,39.64 38.24,39.64 41.36,42.76 41.36,51.87 55.92,66.43 55.92,73.56 58.91,76.55 60.04,76.55 63.14,79.65 63.89,79.65 64.04,79.79 v7(64.04,80.04)
USB3_TX_P2_C: length 2.5
  TOP w0.102: RN13.7 17.09,26.38 17.4,26.08 17.69,26.08 17.91,26.29 18.29,26.29 C493.2
USB3_TX_P2_R: length 9.7
  TOP w0.102: RN13.8 14.42,26.38 14.14,26.1 13.8,26.1 13.67,25.98 13.25,25.98 13.07,26.15 U34.10 U34.1 11.62,26.15 11.47,26 10.32,26 9.69,25.38 9.69,23.38 9.44,23.13 8.99,23.13 8.66,23.45 USB3F.14
USB3_TX_P3: length 127.3
  TOP w0.102: C80.1 95.72,183.48 95.72,182.97 v2(95.94,182.75) ; v7(62.62,92.97) 62.34,93.25 62.34,93.66 62.01,93.99 61.14,93.99 60.58,94.54 58.96,94.54 58.88,94.46 58.56,94.46 58.33,94.23 PCH1.D13
  BOTTOM w0.102: v7(62.62,92.97) 62.34,93.25 62.34,93.66 61.89,94.11 61.89,101.1 60.44,102.55 60.44,110.04 49.31,121.16 49.31,141.51 66.5,158.69 70.06,158.69 74.3,162.93 77.94,162.93 84.96,169.95 84.96,174.27 91.83,181.15 94.85,181.15 95.63,181.92 95.63,182.43 v2(95.94,182.75)
USB3_TX_P3_C: length 2.8
  TOP w0.102: CHOKE8.4 96.22,186.61 95.9,186.28 95.9,186 95.61,185.71 95.61,185.46 96.05,185.02 C80.2
USB3_TX_P3_R: length 7.3
  TOP w0.102: USB3X2.18 95.2,194.8 95.01,194.61 95.01,193.77 95.81,192.97 95.81,192.09 95.97,191.93 U7.6 U7.5 95.97,190.41 95.81,190.25 95.81,189.67 96.19,189.29 RN7.8
USB3_TX_P4: length 122.9
  TOP w0.102: PCH1.B13 59.27,94.05 60.13,94.05 60.44,93.74 60.44,93.26 v7(60.72,92.98) ; C77.1 93.55,183.49 93.55,182.97 v2(93.77,182.75)
  BOTTOM w0.102: v2(93.77,182.75) 93.45,182.42 93.45,182.18 93.15,181.88 91.47,181.88 84.27,174.68 84.27,170.28 77.61,163.62 74,163.62 69.78,159.4 66.22,159.4 48.62,141.8 48.62,120.85 59.69,109.77 59.69,102.28 61.19,100.78 61.19,96.72 60.44,95.97 60.44,93.26 v7(60.72,92.98)
USB3_TX_P4_C: length 3
  TOP w0.102: RN7.3 94.56,186.66 94.26,186.35 94.26,186.18 93.47,185.39 93.47,185.2 C77.2
USB3_TX_P4_R: length 11.6
  TOP w0.102: RN7.4 94.56,189.32 94.29,189.6 94.29,190.19 94.47,190.37 U7.2 U7.9 94.47,192 94.32,192.15 94.32,192.81 92.94,194.19 92.94,195.01 94.21,196.28 94.21,196.74 94.95,197.48 94.95,197.8 95.15,198 USB3X2.9
USB+5: length 30.5
  TOP w0.102: USB2_LAN.U7 71.39,195.33 71.56,195.17 71.56,194.11 69.34,191.89 65.43,191.89 64.77,191.23 64.77,187.97 62.74,185.94 62.74,183.27 61.79,182.31 61.79,179.67 60.74,178.62 60.35,178.62 U13.4 59.89,178.62 58.99,178.62 58.33,179.28 56.76,179.28 56.49,179.01 55.98,179.01 55.63,179.37 RN9.6
USB+6: length 31.2
  TOP w0.102: RN9.2 55.65,180.99 55.98,180.66 56.27,180.66 56.78,181.18 58.48,181.18 59.14,180.52 59.89,180.52 U13.6 60.35,180.52 60.74,180.52 61.09,180.87 61.09,182.63 62.04,183.58 62.04,186.21 64.08,188.25 64.08,191.51 65.23,192.66 67.69,192.66 69.44,194.41 69.44,196.09 70.05,196.7 71.04,196.7 71.54,197.2 71.54,197.87 71.35,198.06 70.77,198.06 USB2_LAN.U3
USB+7: length 12.2
  TOP w0.102: L27.4 11.42,35.52 11.66,35.76 11.94,35.76 12.2,36.02 12.2,36.5 U28.6 12.2,36.96 12.2,37.5 11.54,38.16 11.54,40.74 10.89,41.39 9.99,41.39 8.49,42.89 8.13,42.89 7.79,42.55 F_USB.6
USB+8: length 12.9
  TOP w0.102: F_USB.5 5.25,42.58 5.56,42.89 5.94,42.89 6.52,42.31 6.52,40.99 7.26,40.25 9.32,40.25 9.64,39.93 9.64,38.15 10.3,37.49 10.3,36.96 U28.4 10.3,36.5 10.3,35.92 9.77,35.39 L26.4
USB-5: length 30.7
  TOP w0.102: RN9.8 55.73,178.55 55.98,178.81 56.57,178.81 56.84,179.08 57.39,179.08 U13.3 57.85,179.08 58.24,179.08 58.9,178.42 60.83,178.42 61.99,179.58 61.99,182.23 62.95,183.18 62.95,185.85 64.97,187.88 64.97,191.14 65.51,191.68 69.42,191.68 71.76,194.02 71.76,195.01 72.08,195.33 USB2_LAN.U6
USB-6: length 31.3
  TOP w0.102: USB2_LAN.U2 72,197.95 71.74,197.69 71.74,197.12 71.12,196.5 70.14,196.5 69.65,196.01 69.65,194.33 67.78,192.46 65.32,192.46 64.29,191.43 64.29,188.17 62.25,186.13 62.25,183.5 61.3,182.55 61.3,180.78 60.83,180.32 59.06,180.32 58.4,180.98 57.85,180.98 U13.1 57.39,180.98 56.87,180.98 56.35,180.46 55.98,180.46 55.7,180.18 RN9.4
USB-7: length 12.2
  TOP w0.102: F_USB.4 7.71,44.19 7.71,43.41 8.03,43.1 8.57,43.1 10.07,41.6 10.97,41.6 11.75,40.83 11.75,39.46 U28.1 11.75,39 11.75,38.24 12.41,37.58 12.41,35.93 12.27,35.8 L27.1
USB-8: length 12.9
  TOP w0.102: L26.1 10.62,35.64 10.51,35.76 10.51,37.58 9.85,38.24 9.85,39 U28.3 9.85,39.46 9.85,40.02 9.41,40.46 7.34,40.46 6.72,41.08 6.72,42.4 6.02,43.1 5.82,43.1 5.25,43.67 F_USB.3
USB_EN: length 285.9
  TOP w0.102: v2(23.18,153.9) 23.67,153.41 26.25,153.41 29.99,149.66 47.57,149.66 51.16,153.24 61.02,153.24 64.62,156.84 69.98,156.84 84.5,171.35 87.19,171.35 87.66,171.82 87.66,178.11 89.35,179.81 89.35,182.16 89.61,182.41 R104.1 ; RJ4.2 18.33,10.61 17.91,10.2 R586.1 17.18,9.72 16.55,10.36 v2(16.55,10.34) ; D20.3 24.47,45.74 R460.2 23.64,44.91 22.91,44.91 22.64,45.18 22.64,51.94 17.63,56.95 v2(17.63,57.28) ; v2(12.29,71.06) 12.68,71.06 13.25,70.49 13.25,69.35 15.22,67.38 18.9,67.38 v2(19.79,68.27)
  BOTTOM w0.102: v2(23.18,153.9) 22.4,153.13 21.11,153.13 19.26,154.99 18.97,155.27 15.88,155.27 15.41,154.79 15.41,153.41 14.52,152.52 14.01,152.52 7.49,146 7.49,137.74 6.48,136.72 6.48,131.36 6.86,130.98 6.86,106.08 6.86,105.61 5.88,104.63 5.88,101.66 6.5,101.03 6.5,96.82 5.78,96.09 5.78,86.01 6.54,85.25 6.54,80.7 8.72,78.52 9.84,78.52 10.61,77.76 10.61,76.64 12.17,75.08 12.17,73.26 11.98,73.07 11.98,71.38 v2(12.29,71.06) ; v2(19.79,68.27) 19.48,67.96 19.48,65.34 20.6,64.22 20.6,62.44 17.63,59.47 v2(17.63,57.28) 17.63,55.23 14.54,52.14 14.54,46.18 13.35,44.99 13.35,36.87 11.51,35.02 11.51,18.87 12.27,18.11 12.27,12.85 13.92,11.19 v3(13.92,10.66) 14.24,10.34 v2(16.55,10.34)
USB_EN1: length 53.1
  TOP w0.102: U37.2 21.88,10.07 C575.1 21.53,9.05 20.8,8.32 19.53,8.32 v2(18.87,8.99) R586.2 ; v2(13.11,46.53) 13.03,46.6 U27.4
  BOTTOM w0.102: v2(18.87,8.99) 18,9.86 13.67,9.86 12.4,11.13 v3(12.4,11.6) 9.92,14.08 9.92,33.76 13.12,36.96 13.12,46.51 v2(13.11,46.53)
USB_EN2: length 5.2
  TOP w0.102: R104.2 C89.1 91.03,181.23 90.78,180.98 90.27,180.98 89.95,180.66 89.95,179.2 90.15,179.01 U14.2
USB_H1: length 28.1
  TOP w0.102: CHOKE10.3 88.54,187.03 88.15,187.42 88.15,187.93 87.95,188.13 87.95,188.65 U8.3 87.95,189.1 87.95,189.72 88.61,190.38 88.61,192.43 87.02,194.01 84.37,194.01 83.49,194.89 83.49,197.09 84.46,198.06 85.73,198.06 88.07,200.4 88.92,200.4 89.56,199.76 89.56,199.37 90.7,198.23 90.7,197.75 91.86,196.59 91.86,196.23 91.69,196.06 91.09,196.06 USB3X2.12
USB_H2: length 27.2
  TOP w0.102: CHOKE9.3 86.76,187.11 86.47,187.39 86.47,187.73 86.02,188.19 86.02,188.62 U8.1 86.02,189.13 86.02,189.92 86.71,190.61 86.71,192.45 85.85,193.31 84.1,193.31 82.79,194.62 82.79,197.45 84.17,198.82 85.48,198.82 87.82,201.16 91.04,201.16 91.96,200.24 91.96,199.62 91.59,199.26 91.09,199.26 USB3X2.3
USB_L1: length 28.1
  TOP w0.102: CHOKE10.2 87.69,187.16 87.95,187.42 87.95,187.85 87.74,188.05 87.74,189.81 88.4,190.47 88.4,191.15 U8.4 88.4,191.6 88.4,192.34 86.94,193.81 84.29,193.81 83.29,194.81 83.29,197.17 84.38,198.27 85.65,198.27 87.99,200.6 89,200.6 89.76,199.84 89.76,199.46 90.91,198.32 90.91,197.83 92.06,196.68 92.06,196.5 92.26,196.3 USB3X2.11
USB_L2: length 27.2
  TOP w0.102: CHOKE9.2 85.91,187.03 86.27,187.39 86.27,187.65 85.81,188.11 85.81,190 86.5,190.7 86.5,191.15 U8.6 86.5,191.6 86.5,192.37 85.76,193.11 84.01,193.11 82.59,194.53 82.59,197.53 84.08,199.03 85.4,199.03 87.73,201.36 91.12,201.36 92.16,200.32 92.16,199.71 92.37,199.5 USB3X2.2
USB_N1: length 159
  TOP w0.089: PCH1.AF5 47.04,98.04 46.63,98.04 46.47,98.2 v4(46.47,98.33)
  TOP w0.102: RN8.5 87.63,184.51 87.91,184.23 87.91,183.13 87.83,183.05 v7(87.35,183.05)
  BOTTOM w0.102: v4(46.47,98.33) 46.47,98.3 46.18,98.01 45.62,98.01 44.91,98.73 44.91,108.9 41.78,112.03 38.48,112.03 26.98,123.53 26.98,144.61 28.17,145.81 28.17,148.79 27.36,149.6 27.36,160.83 29.74,163.21 29.74,169.26 31.52,171.04 43.11,171.04 47.09,175.02 47.09,180.28 48.67,181.86 52.98,181.86 56.39,178.44 59.57,178.44 63.06,181.93 81.43,181.93 84,184.5 87.2,184.5 87.91,183.79 87.91,183.13 87.83,183.05 v7(87.35,183.05)
USB_N2: length 156
  TOP w0.089: v4(47.59,97.76) 47.95,98.11 PCH1.AD5
  TOP w0.102: RN8.1 86,184.55 86.31,184.24 86.31,183.97 85.6,183.26 85.6,182.64 85.47,182.52 85.22,182.52 v7(85.01,182.72)
  BOTTOM w0.102: v4(47.59,97.76) 47.46,97.62 47.26,97.62 47.16,97.72 47.16,99.47 46.11,100.52 46.11,108.69 41.87,112.92 38.6,112.92 27.76,123.76 27.76,144.42 28.87,145.52 28.87,149.14 28.04,149.96 28.04,160.5 30.51,162.96 30.51,168.92 31.94,170.35 43.54,170.35 47.8,174.62 47.8,179.94 49.03,181.17 52.65,181.17 56.09,177.73 60.1,177.73 63.53,181.16 81.91,181.16 84.19,183.44 85.31,183.44 85.56,183.18 85.56,182.61 85.47,182.52 85.22,182.52 v7(85.01,182.72)
USB_N3: length 127
  TOP w0.102: v7(7.23,32.97) 7.56,32.64 7.98,32.64 8.93,31.69 18.74,31.69 19.22,31.22 19.22,30.3 18.97,30.05 18.72,30.05 18.42,29.75 RN12.5 ; v4(46.55,96.89) 46.7,96.89 PCH1.AG8
  BOTTOM w0.102: v4(46.55,96.89) 46.4,96.74 45.99,96.74 45.59,96.34 41.39,96.34 40.52,97.2 38.15,97.2 37.36,97.99 35.41,97.99 30.28,103.12 24.6,103.12 22.33,100.84 19.97,100.84 18.97,99.84 17.55,99.84 17.17,99.47 15.48,99.47 14.85,98.84 13.75,98.84 12.9,97.99 12.9,81.12 16.93,77.09 16.93,66.24 16.42,65.73 16.42,61.32 14.33,59.22 14.33,54.27 10.52,50.46 10.52,45.48 11.75,44.24 11.75,37.53 8.15,33.94 8.15,33.03 7.77,32.64 7.56,32.64 v7(7.23,32.97)
USB_N3_R: length 9.6
  TOP w0.102: RN12.6 15.77,29.75 15.72,29.8 13.71,29.8 13.05,30.46 12.35,30.46 U30.4 11.9,30.46 11.06,30.46 9.52,28.92 8.89,28.92 8.66,28.69 USB3F.12
USB_N4: length 113
  TOP w0.102: PCH1.AE1 47.73,100.93 48.29,101.48 48.29,102.29 50.41,104.41 50.65,104.41 v4(50.89,104.65) ; RN12.1 18.57,28.12 18.87,28.43 19.22,28.43 19.5,28.71 20.19,28.71 v7(20.55,28.35)
  BOTTOM w0.102: v7(20.55,28.35) 20.89,28.69 21.77,28.69 24.33,31.26 24.33,34.26 25.21,35.13 25.21,44.29 26.14,45.22 28.77,45.22 33.9,50.35 39.14,50.35 55.44,66.65 55.44,77.12 56.05,77.73 56.05,81.86 53.62,84.28 53.62,87.94 54.17,88.49 54.17,93.33 53.26,94.23 50,94.23 49.45,94.77 49.45,96.22 52.88,99.65 52.88,103.46 51.9,104.44 51.11,104.44 v4(50.89,104.65)
USB_N4_R: length 11.1
  TOP w0.102: USB3F.8 7.56,26.92 9.43,26.92 10.4,27.9 13.08,27.9 13.74,28.56 14.39,28.56 U30.1 14.85,28.56 15.49,28.56 15.93,28.12 RN12.2
USB_N5: length 111.1
  TOP w0.102: v4(50.29,102.93) 50.29,102.74 50.11,102.56 49.64,102.56 49.03,101.95 49.03,99.88 48.96,99.8 48.96,99.49 PCH1.AC2 ; v7(52.26,178.53) 52.26,178.77 52.43,178.94 52.79,178.94 53.18,178.55 RN9.7
  BOTTOM w0.102: v7(52.26,178.53) 52.26,178.8 52.15,178.91 51.66,178.91 51.36,178.61 51.36,174.74 45.6,168.98 32.61,168.98 31.93,168.29 31.93,162.4 29.44,159.91 29.44,150.69 30.26,149.87 30.26,144.96 29.24,143.93 29.24,125.91 40.63,114.51 42.31,114.51 49.66,107.17 49.66,102.82 49.89,102.58 50.06,102.58 50.29,102.81 v4(50.29,102.93)
USB_N6: length 113.1
  TOP w0.102: v4(48.79,104.49) 48.79,104.38 48.51,104.11 48.16,104.11 47.71,103.66 47.71,101.8 47.26,101.34 47.26,99.63 47.2,99.57 PCH1.AF2 ; v7(50.79,179.59) 50.58,179.59 50.37,179.8 50.37,180.03 50.82,180.49 52.86,180.49 53.16,180.18 RN9.3
  BOTTOM w0.102: v7(50.79,179.59) 50.57,179.59 50.37,179.39 50.37,174.92 49.57,174.12 48.3,174.12 43.84,169.66 32.29,169.66 31.22,168.59 31.22,162.68 28.75,160.22 28.75,150.31 29.57,149.5 29.57,145.23 28.5,144.16 28.5,125.63 40.38,113.75 42.06,113.75 47.01,108.8 47.01,105.31 48.24,104.08 48.49,104.08 48.79,104.38 v4(48.79,104.49)
USB_N7: length 108.9
  TOP w0.089: v7(51.53,100.29) 51.53,100.53 51.38,100.68 50.17,100.68 49.66,100.17 49.66,99.46 49.39,99.2 PCH1.AB3
  TOP w0.102: RN11.7 12.24,32.97 11.94,32.67 11.94,32.53 12.06,32.4 19.17,32.4 19.89,31.68 20.8,31.68 20.93,31.81 v2(20.93,31.97)
  BOTTOM w0.102: v2(20.93,31.97) 20.93,31.67 21.03,31.57 21.82,31.57 22.43,32.17 22.43,33.88 24.31,35.76 24.31,44.69 25.74,46.12 28.31,46.12 33.52,51.33 38.84,51.33 54.55,67.04 54.55,81.42 52.73,83.23 52.73,88.34 53.26,88.88 53.26,91.78 52.91,92.13 52.02,92.13 50.82,93.34 49.67,93.34 48.67,94.35 48.67,96.61 52.17,100.12 52.17,100.39 51.93,100.63 51.64,100.63 51.53,100.52 v7(51.53,100.29)
USB_N8: length 117.6
  TOP w0.089: v4(45.33,96.79) 45.03,96.49 PCH1.AL8
  TOP w0.102: RN11.3 10.62,32.94 10.31,32.63 10.31,32.44 10.07,32.2 9.12,32.2 8.52,32.8 8.52,34.04 8.22,34.33 7.49,34.33 v2(7.23,34.07)
  BOTTOM w0.102: v4(45.33,96.79) 45.32,96.79 45.09,97.02 44.68,97.02 44.48,96.82 41.53,96.82 40.74,97.61 38.2,97.61 37.39,98.42 35.7,98.42 30.52,103.6 23.47,103.6 22.14,102.27 20.38,102.27 19.38,101.27 17.77,101.27 17.39,101.64 15.8,101.64 14.8,102.64 13.81,102.64 12.94,101.78 12.94,98.85 12.4,98.31 12.4,80.9 16.43,76.86 16.43,67.04 15.93,66.53 15.93,61.55 13.83,59.45 13.83,54.47 9.58,50.21 9.58,36.08 7.86,34.36 7.52,34.36 v2(7.23,34.07)
USB_OC2_L: length 9.7
  TOP w0.089: v2(47.6,73.48) R390.1 ; PCH1.AD39 47.96,81 v4(47.6,81.24)
  BOTTOM w0.102: v2(47.6,73.48) v3(47.6,74.41) 48.08,74.9 48.08,80.76 v4(47.6,81.24)
USB_OC3_L: length 3.2
  TOP w0.089: v7(49.12,76.97) 48.55,77.54 48.55,78.51 48.69,78.64 PCH1.AC44
  BOTTOM w0.089: v7(49.12,76.97) 49.54,76.97 STP24.1
USB_OC7_L: length 7.9
  TOP w0.089: R392.1 50.64,72.57 v2(50.64,73.42) 50.64,78.59 50.68,78.63 50.68,79.17 PCH1.W43
  BOTTOM w0.102: v2(50.64,73.42) 50.65,73.41 v3(50.65,72.56)
USB_P1: length 159
  TOP w0.089: PCH1.AG7 46.76,97.35 v4(46.45,97.67)
  TOP w0.102: v2(88.43,183.08) 88.11,183.39 88.11,184.22 88.44,184.55 RN8.7
  BOTTOM w0.102: v2(88.43,183.08) 88.11,183.39 88.11,183.87 87.28,184.7 83.91,184.7 81.35,182.14 62.98,182.14 59.49,178.64 56.48,178.64 53.06,182.06 48.58,182.06 46.89,180.37 46.89,175.1 43.03,171.24 31.44,171.24 29.54,169.34 29.54,163.3 27.15,160.91 27.15,149.51 27.97,148.7 27.97,145.89 26.77,144.7 26.77,123.45 38.39,111.83 41.69,111.83 44.7,108.82 44.7,98.64 45.54,97.81 46.31,97.81 v4(46.45,97.67)
USB_P2: length 156.1
  TOP w0.089: v4(47.59,97) 47.95,97.35 PCH1.AD7
  TOP w0.102: RN8.3 86.82,184.59 86.51,184.28 86.51,183.89 85.8,183.18 85.8,182.97 v2(86.14,182.63)
  BOTTOM w0.102: v4(47.59,97) 46.96,97.63 46.96,99.38 45.9,100.44 45.9,108.6 41.79,112.72 38.52,112.72 27.56,123.68 27.56,144.5 28.66,145.61 28.66,149.05 27.84,149.88 27.84,160.58 30.3,163.04 30.3,169 31.85,170.55 43.45,170.55 47.6,174.7 47.6,180.03 48.95,181.37 52.73,181.37 56.17,177.93 60.01,177.93 63.44,181.36 81.83,181.36 84.1,183.64 85.39,183.64 85.76,183.27 85.76,183.01 v2(86.14,182.63)
USB_P3: length 126.8
  TOP w0.102: PCH1.AG10 46.81,95.83 46.5,96.14 v4(46.5,96.26) ; v2(7.23,32.11) 7.23,32.33 7.34,32.44 7.89,32.44 8.84,31.49 18.66,31.49 19.01,31.13 19.01,30.38 18.89,30.26 18.68,30.26 18.38,30.56 RN12.7
  BOTTOM w0.102: v4(46.5,96.26) 46.5,96.34 46.3,96.54 46.08,96.54 45.67,96.13 41.3,96.13 40.44,97 38.07,97 37.28,97.78 35.32,97.78 30.19,102.91 24.69,102.91 22.42,100.64 20.06,100.64 19.06,99.64 17.63,99.64 17.26,99.27 15.56,99.27 14.94,98.64 13.84,98.64 13.11,97.91 13.11,81.2 17.13,77.18 17.13,66.15 16.62,65.64 16.62,61.23 14.53,59.14 14.53,54.18 10.72,50.37 10.72,45.56 11.95,44.33 11.95,37.45 8.36,33.85 8.36,32.94 7.86,32.44 7.33,32.44 7.23,32.34 v2(7.23,32.11)
USB_P3_R: length 9.8
  TOP w0.102: RN12.8 15.9,30.56 15.34,30 14.85,30 U30.3 14.39,30 13.79,30 13.13,30.66 10.98,30.66 9.44,29.13 8.87,29.13 8.66,29.33 USB3F.11
USB_P4: length 113.1
  TOP w0.102: v2(20.55,29.22) 20.55,29.06 20.4,28.91 19.42,28.91 19.14,28.63 18.85,28.63 18.54,28.94 RN12.3 ; v7(50.89,103.89) 50.89,104.09 50.78,104.21 50.49,104.21 48.49,102.21 48.49,101.4 47.94,100.84 47.94,100.16 47.97,100.13 47.97,99.72 PCH1.AE2
  BOTTOM w0.102: v7(50.89,103.89) 50.89,104.12 51,104.23 51.82,104.23 52.68,103.37 52.68,99.73 49.25,96.31 49.25,94.68 49.91,94.02 53.18,94.02 53.96,93.24 53.96,88.57 53.42,88.02 53.42,84.2 55.84,81.77 55.84,77.81 55.23,77.2 55.23,66.73 39.05,50.55 33.82,50.55 28.69,45.42 26.05,45.42 25.01,44.37 25.01,35.22 24.13,34.34 24.13,31.34 21.68,28.9 20.65,28.9 20.55,29 v2(20.55,29.22)
USB_P4_R: length 11
  TOP w0.102: USB3F.9 7.56,27.13 9.35,27.13 10.32,28.1 11.9,28.1 U30.6 12.35,28.1 12.99,28.1 13.65,28.76 15.65,28.76 15.82,28.94 RN12.4
USB_P5: length 111.3
  TOP w0.102: v2(52.26,179.39) 52.52,179.14 52.93,179.14 53.16,179.37 RN9.5 ; PCH1.AC3 48.88,99.04 49.16,99.32 49.16,99.72 49.24,99.79 49.24,101.86 49.73,102.35 50.1,102.35 v7(50.29,102.16)
  BOTTOM w0.102: v7(50.29,102.16) 50.08,102.38 49.81,102.38 49.45,102.74 49.45,107.08 42.23,114.31 40.55,114.31 29.03,125.82 29.03,144.01 30.06,145.04 30.06,149.78 29.24,150.61 29.24,160 31.73,162.48 31.73,168.38 32.53,169.18 45.52,169.18 51.16,174.82 51.16,178.69 51.58,179.11 51.98,179.11 v2(52.26,179.39)
USB_P6: length 113.3
  TOP w0.102: RN9.1 53.2,180.99 52.9,180.69 50.74,180.69 50.17,180.12 50.17,179.83 v2(49.92,179.59) ; PCH1.AF3 47.12,99.2 47.46,99.54 47.46,101.26 47.92,101.71 47.92,103.58 48.24,103.9 48.61,103.9 v7(48.79,103.73)
  BOTTOM w0.102: v2(49.92,179.59) 50.17,179.35 50.17,175.01 49.48,174.33 48.21,174.33 43.76,169.87 32.21,169.87 31.01,168.67 31.01,162.76 28.55,160.3 28.55,150.23 29.36,149.41 29.36,145.31 28.3,144.25 28.3,125.55 40.3,113.54 41.98,113.54 46.81,108.72 46.81,105.22 48.15,103.88 48.63,103.88 v7(48.79,103.73)
USB_P7: length 108.9
  TOP w0.089: PCH1.AB2 49.47,99.65 49.47,100.25 50.09,100.87 51.35,100.87 v4(51.53,101.05)
  TOP w0.102: v7(20.93,31.11) 20.56,31.48 19.81,31.48 19.09,32.2 11.98,32.2 11.74,32.44 11.74,32.64 11.43,32.95 RN11.5
  BOTTOM w0.102: v4(51.53,101.05) 51.75,100.83 52.02,100.83 52.38,100.47 52.38,100.03 48.87,96.53 48.87,94.43 49.76,93.54 50.9,93.54 52.11,92.33 53,92.33 53.47,91.86 53.47,88.79 52.93,88.26 52.93,83.32 54.75,81.5 54.75,66.95 38.92,51.12 33.6,51.12 28.39,45.92 25.82,45.92 24.51,44.61 24.51,35.68 22.63,33.8 22.63,32.09 21.9,31.36 21.18,31.36 v7(20.93,31.11)
USB_P8: length 117.5
  TOP w0.089: PCH1.AL7 45.12,97.25 v4(45.32,97.45)
  TOP w0.102: v7(7.23,34.93) 7.23,34.71 7.4,34.54 8.31,34.54 8.72,34.12 8.72,32.88 9.2,32.4 9.99,32.4 10.11,32.53 10.11,32.64 9.8,32.95 RN11.1
  BOTTOM w0.102: v4(45.32,97.45) 45.09,97.22 44.6,97.22 44.39,97.02 41.61,97.02 40.83,97.81 38.29,97.81 37.47,98.62 35.79,98.62 30.61,103.8 23.39,103.8 22.05,102.47 20.3,102.47 19.3,101.47 17.85,101.47 17.48,101.84 15.88,101.84 14.88,102.84 13.72,102.84 12.74,101.86 12.74,98.94 12.19,98.39 12.19,80.82 16.23,76.78 16.23,67.13 15.72,66.62 15.72,61.63 13.63,59.54 13.63,54.55 9.37,50.3 9.37,36.16 7.77,34.56 7.35,34.56 7.23,34.69 v7(7.23,34.93)
VBOOT/ADDR: length 6.6
  TOP w0.203: 172.03,184.7 U10.28
  TOP w0.254: 172.03,184.7 172.03,186.7 R67.2 172.54,187.05 172.95,187.46 172.95,188.47 172.79,188.63 172.79,189.43 173.01,189.65 R51.2
VBOOT_V1P05_N1: length 2.7
  TOP w0.102: R51.1 173.46,190.82 173.84,191.21 Q8.D
VBOOTA/ADDRA: length 3.4
  TOP w0.203: 172.43,184.72 U10.27
  TOP w0.254: 172.43,184.72 172.43,185.54 173.46,186.57 R68.2
VCORE_GSENS: length 62.4
  TOP w0.203: CPU.D38 140.9,128.79 v7(140.9,128.83) ; C111.1 162.79,176.85 162.28,176.35 161.65,176.35 161.01,175.71 R141.1 R140.2 159.58,176.66 R132.1 158.67,176.26 157.71,176.26 v2(157.63,176.18)
  BOTTOM w0.203: v2(157.63,176.18) 157.36,176.18 156.46,175.29 156.46,161.04 152.46,157.04 152.46,141.56 144.53,133.62 144.53,132.75 140.9,129.13 v7(140.9,128.83)
VCORE_GT_GSENS: length 79.8
  TOP w0.203: v7(140.05,127) 140.48,126.57 CPU.F38 ; v4(159.83,170.89) 160.06,170.66 160.68,170.66 163.84,167.49 164.52,166.82 167.3,166.82 167.63,166.49 175.78,166.49 176.89,167.6 R177.2 177.48,169.1 177.48,170.82 R159.1 178.07,171.4 178.07,173.23 C130.1
  BOTTOM w0.203: v7(140.05,127) 140.33,126.71 140.97,126.71 141.25,127 142.14,127 145.44,130.29 145.44,133.41 153.2,141.17 153.2,156.6 158.75,162.15 158.75,169.81 v4(159.83,170.89)
VCORE_GT_SENS: length 81.4
  TOP w0.203: v7(140.03,126.07) 140.92,126.07 CPU.F39 ; R150.1 R160.1 179.05,171.8 178.35,171.11 178.35,168.5 175.94,166.08 167.46,166.08 167.13,166.41 164.35,166.41 163.56,167.21 160.51,170.25 159.96,170.25 v4(159.83,170.12)
  BOTTOM w0.203: v7(140.03,126.07) 140.27,126.31 141.14,126.31 141.42,126.59 142.31,126.59 145.84,130.13 145.84,133.24 153.61,141 153.61,156.43 159.16,161.98 159.16,169.64 159.64,170.12 v4(159.83,170.12)
VCORE_SENS: length 60.4
  TOP w0.203: R133.1 159.65,178 R124.1 158.71,177.38 158.71,177.25 R132.2 157.77,176.92 v2(157.65,177.04) ; CPU.C38 v7(140.02,128.82)
  BOTTOM w0.203: v2(157.65,177.04) 156.06,175.46 156.06,161.21 152.06,157.21 152.06,141.73 144.12,133.79 144.12,132.92 v7(140.02,128.82)
VGA_BLUE: length 22.1
  TOP w0.102: FB3.1 C40.1 v1(119.77,192.78) v2(119.77,191.74) ; v2(107.93,198.76) 107.93,199.49 R17.1 107.64,199.62 107.29,199.27 107.29,197.93 107.41,197.81 U4.21
  BOTTOM w0.102: v2(107.93,198.76) 108.29,198.39 110.8,198.39 112.45,196.74 112.45,195.44 114.67,193.22 118.29,193.22 v2(119.77,191.74)
VGA_BLUE_CONN: length 11.9
  TOP w0.102: VGA.3 121.35,203.31 119.46,201.43 U1.3 118.79,200.47 118.47,200.14 118.47,198.19 119.32,197.33 C18.1 119.55,197.17 120.37,196.35 120.37,195.17 FB3.2
VGA_DDCCLK_CNN: length 34.8
  TOP w0.102: R22.2 113.64,197.05 v2(114.28,196.41) ; VGA.15 127.74,206.25 127.74,203.46 126.34,202.06 125.26,202.06 124.1,200.91 124.1,198.9 124.43,198.57 U2.1 125.11,198.07 C22.1 124.92,196.79 124.92,195.4 R32.2 123.94,194.42 v2(123.94,192.98)
  BOTTOM w0.102: v2(123.94,192.98) 123.83,193.1 123.83,195.81 122.82,196.82 114.68,196.82 v2(114.28,196.41)
VGA_DDCSDA_CNN: length 47.5
  TOP w0.102: v2(124.89,192.35) 125.35,192.35 125.93,192.93 125.93,194.37 R33.2 125.98,195.39 125.98,196.8 C23.1 126.7,198.58 126.7,199.89 126.11,200.47 U2.3 125.11,201.19 125.56,201.64 126.55,201.64 128.12,203.21 128.12,207.78 126.59,209.3 120.3,209.3 VGA.12 ; R21.2 113.39,198.13 v2(114.28,197.24)
  BOTTOM w0.102: v2(114.28,197.24) 114.34,197.3 123.55,197.3 124.89,195.95 v2(124.89,192.35)
VGA_GREEN: length 21.4
  TOP w0.102: v2(106.34,198.82) R16.1 106.56,199.62 107.01,199.17 U4.22 ; v2(117.35,191.74) v1(117.35,192.78) C39.1 FB2.1
  BOTTOM w0.102: v2(117.35,191.74) 116.49,192.61 114.42,192.61 111.84,195.19 111.84,196.49 110.54,197.78 107.13,197.78 106.34,198.57 v2(106.34,198.82)
VGA_GREEN_CONN: length 11.5
  TOP w0.102: FB2.2 118.31,195.11 118.78,195.59 118.78,196.76 C17.1 117.98,197.56 117.98,200.17 117.68,200.47 U1.4 116.96,201.12 119.06,203.21 VGA.2
VGA_HSYNC: length 19.4
  TOP w0.102: U4.19 108.21,197.71 109.13,198.63 v2(109.13,199.4) ; R30.1 122.15,193.43 v2(121.77,193.05)
  BOTTOM w0.102: v2(109.13,199.4) 109.53,199 111.24,199 113.06,197.18 113.06,195.9 115.13,193.83 120.01,193.83 v3(120.35,193.49) 120.79,193.05 v2(121.77,193.05)
VGA_HSYNC_CNN: length 19
  TOP w0.102: VGA.13 121.93,208.06 123.67,206.32 123.67,205.62 124.76,204.53 124.76,203.58 122.42,201.24 121.39,201.24 120.78,200.63 120.78,199.75 121.96,198.57 U2.6 122.61,198.07 122.21,197.67 C20.1 122.73,196.81 122.73,195.44 R30.2
VGA_RED: length 21.6
  TOP w0.102: v2(114.94,191.74) v1(114.94,192.78) C38.1 FB1.1 ; U4.23 106.61,197.73 106.08,198.25 105.32,198.25 104.69,198.89 R15.1 v2(105.39,199.62)
  BOTTOM w0.102: v2(105.39,199.62) 105.39,198.32 106.53,197.17 110.29,197.17 111.23,196.24 111.23,194.94 114.42,191.74 v2(114.94,191.74)
VGA_RED_CONN: length 11.9
  TOP w0.102: FB1.2 115.88,195.06 115.88,196.3 116.62,197.05 C25.1 116.62,197.74 116.96,198.08 U1.6 115.92,198.57 114.92,199.57 114.92,201.33 116.77,203.17 VGA.1
VGA_VSYNC: length 21.1
  TOP w0.102: v2(122.85,193.03) 123.23,193.41 R31.1 ; v2(109.64,200.09) 109.64,198.76 108.61,197.73 U4.18
  BOTTOM w0.102: v2(122.85,193.03) 121.44,194.44 115.2,194.44 113.54,196.1 113.54,197.38 111.08,199.84 v3(110.69,199.84) 109.89,199.84 v2(109.64,200.09)
VGA_VSYNC_CNN: length 19.2
  TOP w0.102: VGA.14 124.22,208.06 127.1,205.18 127.1,203.58 126.07,202.55 124.41,202.55 122.61,200.75 U2.4 123.35,200.47 123.6,200.22 123.6,197.94 123.29,197.63 C21.1 123.83,196.8 123.83,195.45 R31.2
VPP_PGOOD: length 1.8
  TOP w0.102: v2(104.06,27.56) 104.06,28.38 U29.1
  BOTTOM w0.102: STP32.1 104.07,27.55 v2(104.06,27.56)
VR_ALERT: length 5.2
  TOP w0.102: R147.1 166.25,174.28 167.55,175.58 167.55,176.16 168.83,177.43 U10.4
VR_COMP: length 9.8
  TOP w0.203: 166,180.16 166.22,180.37 U10.48
  TOP w0.254: 166,180.16 165.88,180.03 162.79,180.03 162.41,179.65 161.3,179.65 C103.2 160.57,179.14 160,179.71 160,180.7 C93.2
VR_COMP_R: length 1.1
  TOP w0.254: R113.2 C93.1
VR_COMPA: length 7.5
  TOP w0.203: 173.62,180.37 U10.18
  TOP w0.254: C109.2 178.79,177.04 178.22,177.62 176.73,177.62 C106.2 176.01,178.19 173.82,180.37 173.62,180.37
VR_COMPA_R: length 2
  TOP w0.254: R123.2 179.01,178.19 C106.1
VR_CSCOMP: length 48
  TOP w0.203: 166.33,180.77 U10.47
  TOP w0.254: 166.33,180.77 166.07,180.77 165.71,180.41 163.58,180.41 R110.2 162.92,180.92 162.03,180.03 161.17,180.03 160.79,180.41 C98.1 C87.1 160.71,182.27 160.31,182.27 160.3,182.25 v2(158.98,182.25) 158.98,183.24 R100.1 ; v2(150.34,152.53) 150.72,152.15 150.72,151.29 RT2.1
  BOTTOM w0.254: v2(150.34,152.53) 150.6,152.79 150.6,158.51 152.86,160.77 152.86,175.78 158.73,181.65 158.73,182 v2(158.98,182.25)
VR_CSCOMP_NTC: length 37.2
  TOP w0.254: v2(149.91,153.23) 149.71,153.03 149.71,152.12 RT2.2 ; R100.2 R99.1 157.36,182.86 v2(157.96,182.25)
  BOTTOM w0.254: v2(157.96,182.25) 158.22,182 158.22,181.68 152.48,175.94 152.48,160.93 150.22,158.67 150.22,153.54 v2(149.91,153.23)
VR_CSCOMPA: length 87.5
  TOP w0.203: 173.86,180.77 U10.19
  TOP w0.254: 173.86,180.77 173.96,180.77 175.91,178.82 176.6,178.82 R117.2 178.29,179.33 178.64,178.99 v2(179.86,178.99) 180.03,179.16 C101.1 C100.1 181.17,180.79 R106.1 ; v2(177.08,119.2) 176.92,119.04 RT4.1
  BOTTOM w0.254: v2(177.08,119.2) 177.39,119.51 177.39,125.48 175.87,127.01 172.45,127.01 170.54,128.92 170.54,137.16 172.07,138.69 174.8,138.69 175.87,139.76 175.87,143.55 173.39,146.02 173.39,147.52 170.6,150.32 170.6,157.35 173.46,160.21 173.46,169.3 175.97,171.81 177.35,171.81 180.11,174.57 180.11,178.73 v2(179.86,178.99)
VR_CSCOMPA_NTC: length 80.1
  TOP w0.254: R102.1 181.46,181.81 182.12,181.14 R106.2 182.12,180.36 v2(180.72,178.96) ; v2(177.87,119.2) RT4.2
  BOTTOM w0.254: v2(180.72,178.96) 180.49,178.73 180.49,174.41 177.5,171.43 176.12,171.43 173.9,169.2 173.9,160.03 171.04,157.17 171.04,150.5 173.84,147.71 173.84,146.21 176.31,143.73 176.31,139.58 174.98,138.25 172.25,138.25 170.98,136.98 170.98,129.1 172.63,127.45 176.05,127.45 177.84,125.67 177.84,119.23 v2(177.87,119.2)
VR_CSN1: length 55.3
  TOP w0.203: v2(147.3,155.82) 146.46,155.82 SP6.2 ; U10.38 168.03,184.38 167.23,185.17 167.23,185.81 166.19,186.85 166.19,187.39 C62.2 166.03,188.44 166.03,189.78 R52.2 165.01,190.41 R59.2 163.2,190.25 159.97,190.25 v2(159.84,190.13)
  BOTTOM w0.203: v2(147.3,155.82) 147.3,155.86 148.02,156.59 148.02,159.85 150.11,161.94 150.11,178.76 157.99,186.63 157.99,188.03 158.85,188.89 158.85,189.61 159.36,190.13 v2(159.84,190.13)
VR_CSN1A: length 85.5
  TOP w0.203: v2(176.63,124.53) 176.87,124.29 176.87,123.37 SP11.2 ; U10.26 172.94,185.29 173.98,186.33 173.98,187.44 C64.2 R69.2 175.84,188.22 v2(175.84,188.79) 175.58,189.05 R56.2
  BOTTOM w0.203: v2(176.63,124.53) 176.38,124.53 175.11,125.8 171.55,125.8 169.39,127.96 169.39,140.61 172.23,143.44 172.23,146.84 169.39,149.67 169.39,162.12 171.35,164.08 171.35,169.62 171.81,170.07 171.81,172.92 175.97,177.08 175.97,182.77 177.31,184.11 177.31,186.95 176.3,187.96 175.84,188.41 175.84,188.79 v2(175.84,188.79)
VR_CSN2: length 79.9
  TOP w0.203: SP5.2 129.64,155.83 130.04,155.83 v2(130.26,155.61) ; v2(159.61,188.41) 159.59,188.39 159.59,188.29 160.11,187.78 160.92,187.78 R64.2 162.28,188.28 162.85,188.86 163.61,188.86 164.03,188.44 R62.2 C65.2 164.03,186.92 165.08,185.87 165.08,184.79 166.29,183.57 U10.40
  BOTTOM w0.203: v2(159.61,188.41) 159.61,186.67 151.38,178.44 151.38,161.41 149.14,159.16 149.14,155.79 147.91,154.56 144.44,154.56 143.07,153.19 143.07,150.97 140.18,148.09 132.81,148.09 130.89,150.01 130.89,155.44 130.72,155.61 v2(130.26,155.61)
VR_CSN2A: length 92.9
  TOP w0.203: v2(176.64,114.88) 176.87,114.65 176.87,114.23 SP13.2 ; U10.24 173.53,182.77 174.03,183.27 175.55,183.27 176,182.82 C84.2
  TOP w0.254: C84.2 R98.2 177.17,184.86 R80.2 177.17,185.84 176.83,186.18 175.98,186.18 175.59,185.79 175.59,185.45 175.12,184.98 v2(174.6,184.98)
  BOTTOM w0.203: v2(174.6,184.98) 174.85,184.73 174.85,184.35 173.56,183.05 173.56,178.29 170.66,175.39 170.66,170.53 170.13,170 170.13,164.73 168.22,162.82 168.22,149.06 171.08,146.2 171.08,143.95 168.22,141.09 168.22,127.54 171.13,124.63 174.69,124.63 175.74,123.58 175.74,118.24 176.82,117.16 176.82,115.06 v2(176.64,114.88)
VR_CSN3: length 65.1
  TOP w0.203: v2(170.28,144.91) 170.51,145.14 174.31,145.14 176.81,142.65 176.81,142.24 SP8.2 ; U10.42 165.89,182.77 164.95,183.71 C81.2 R84.2 164.03,185.01 163.68,185.36 161.2,185.36 160.69,185.87 R76.2 160.53,185.08 v2(160.5,185.04)
  BOTTOM w0.203: v2(160.5,185.04) 160.5,184.28 160.88,183.9 160.88,180.85 163.46,178.28 165.68,178.28 169.01,174.95 169.01,166.1 167.08,164.17 167.08,148.11 v2(170.28,144.91)
VR_CSP1: length 43.6
  TOP w0.203: SP4.2 146.46,156.23 146.9,156.23 v2(147.32,156.65) ; R57.2 157.52,189.43 v2(157.84,189.74) 158.34,189.74 158.66,189.43 R58.1
  BOTTOM w0.203: v2(147.32,156.65) 147.61,156.94 147.61,160.02 149.71,162.11 149.71,178.93 157.58,186.8 157.58,188.2 158.44,189.05 158.44,189.52 158.21,189.74 v2(157.84,189.74)
VR_CSP1_IC: length 11.6
  TOP w0.203: R52.1 164.82,188.89 v2(164.82,187.27) 165.36,187.27 C62.1 165.58,186.89 166.85,185.62 166.85,185.04 167.63,184.27 U10.39
  TOP w0.254: v2(162.22,189.68) 161.68,189.68 R58.2
  BOTTOM w0.254: v2(164.82,187.27) 164.76,187.27 162.34,189.68 v2(162.22,189.68)
VR_CSP1_R: length 1.1
  TOP w0.254: R63.2 R57.1
VR_CSP1A: length 79.3
  TOP w0.203: R71.2 R70.1 176.7,188.73 v2(176.76,188.79) ; SP12.2 177.28,123.37 177.28,124.71 176.7,125.29 v2(176.44,125.29)
  BOTTOM w0.203: v2(176.76,188.79) 176.76,188.77 176.75,188.76 176.75,188.08 177.71,187.12 177.71,183.94 176.38,182.6 176.38,176.91 172.21,172.75 172.21,169.9 171.76,169.45 171.76,163.91 169.8,161.96 169.8,149.84 172.63,147.01 172.63,143.27 169.8,140.44 169.8,128.13 171.72,126.21 175.28,126.21 176.19,125.29 v2(176.44,125.29)
VR_CSP1A_IC: length 6.9
  TOP w0.203: U10.25 173.3,183.17 173.84,183.71 173.84,185.43 174.54,186.13 C64.1 R69.1 R70.2
VR_CSP1A_R: length 9.7
  TOP w0.254: v2(179.3,186.89) 179.14,187.05 R71.1 ; v2(178.09,180.73) 177.43,180.73 R112.2
  BOTTOM w0.254: v2(179.3,186.89) 179.3,183.74 177.72,182.17 177.72,181.1 v2(178.09,180.73)
VR_CSP2: length 71.6
  TOP w0.203: SP3.2 129.62,156.24 130.04,156.24 v2(130.26,156.47) ; v2(159.04,187.78) 159.64,187.78 159.97,187.45 160.99,187.45 R74.2 162.12,186.95 R75.1
  BOTTOM w0.203: v2(130.26,156.47) 130.72,156.01 130.89,156.01 131.29,155.61 131.29,150.18 132.98,148.49 140.01,148.49 142.66,151.14 142.66,153.36 144.27,154.97 147.74,154.97 148.73,155.96 148.73,159.33 150.98,161.58 150.98,178.61 159.21,186.84 159.21,187.61 v2(159.04,187.78)
VR_CSP2_IC: length 7.5
  TOP w0.203: R62.1 C65.1 163.07,186.95 R75.2 164.69,185.33 164.69,184.54 166.06,183.17 U10.41
VR_CSP2_R: length 1.1
  TOP w0.254: R74.1 R73.2
VR_CSP2A: length 89.7
  TOP w0.203: v2(174.98,185.68) 175.83,186.53 178.31,186.53 179.39,185.44 R82.2 R97.1 ; v2(177.51,114.88) 177.28,114.65 177.28,114.1 SP14.2
  BOTTOM w0.203: v2(177.51,114.88) 177.23,115.16 177.23,117.33 176.15,118.41 176.15,123.74 174.86,125.04 171.3,125.04 168.63,127.7 168.63,140.92 171.49,143.78 171.49,146.37 168.63,149.23 168.63,162.66 170.54,164.56 170.54,169.83 171.07,170.36 171.07,175.23 173.97,178.12 173.97,182.88 175.26,184.18 175.26,185.4 v2(174.98,185.68)
VR_CSP2A_IC: length 12.8
  TOP w0.203: C84.1 176.54,182.19 176.08,182.19 175.57,182.7 173.97,182.7 173.64,182.37 U10.23
  TOP w0.254: R86.1 177.17,184.03 R98.1 C84.1 178.16,182.82 179.05,181.93 179.45,181.93 180.35,182.83 R97.2
VR_CSP2A_R: length 1.1
  TOP w0.254: R82.1 181.43,185.17 R87.2
VR_CSP3: length 58.3
  TOP w0.203: R92.1 161.42,184.7 v2(161.2,184.47) 160.29,184.47 159.97,184.79 159.97,185.29 R78.2 ; v2(170.28,145.67) 170.41,145.55 174.48,145.55 177.21,142.82 177.21,142.24 SP9.2
  BOTTOM w0.203: v2(170.28,145.67) 170.09,145.67 167.49,148.28 167.49,164 169.42,165.93 169.42,175.12 165.85,178.69 163.63,178.69 161.29,181.02 161.29,184.38 v2(161.2,184.47)
