# Allegro board ECS H11H4-AI-V1.0-OK.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_VTT_CNTL: length 54.2
  TOP w0.254: CPU.AC36 138.19,111.45 v7(138.19,112.36) ; R349.1 v2(181.27,95.89)
  BOTTOM w0.254: v2(181.27,95.89) 180.19,96.97 v3(177.97,96.97) 175.02,96.97 157.15,114.84 143.33,114.84 141.94,113.45 139.28,113.45 v7(138.19,112.36)
DDR_VTT_CNTL_EN: length 5.5
  TOP w0.203: C487.2 134.62,28.2 134.48,28.34 v1(134.14,28.34) 133.94,28.15 U32.5
  TOP w0.254: R495.2 137.28,28.76 135.63,28.76 C487.2
DDRVTT_CNTL: length 8.2
  TOP w0.102: QN2.3 v1(185.63,88.16)
  TOP w0.254: R359.2 D16.2 189.33,89.6 189.08,89.86 186.92,89.86 186.6,90.18 QN2.3
DEPOP_N1: length 6.7
  TOP w0.102: Q17.B 26.58,173.93 25.57,174.95 24.89,174.95 v1(24.38,175.46) 24.11,175.74 24.11,176.54 23.57,177.08 R135.1
DEPOP_N2: length 14.6
  TOP w0.254: v2(14.77,179.65) 14.77,179.63 14.41,180 R111.1 ; v2(21.74,172.03) Q16.B
  BOTTOM w0.254: v2(21.74,172.03) 21.74,172.23 19.58,174.39 18.29,174.39 16.03,176.65 v3(16.03,177.82) 16.03,178.38 14.77,179.63 v2(14.77,179.65)
DEPOP_N3: length 12
  TOP w0.254: R154.1 19.88,171.55 20.24,171.19 23.52,171.19 24.36,172.03 Q16.E 25.76,171.27 27.34,171.27 v7(27.6,171.52) 28.11,172.03 Q17.E 30.2,172.03
DEPOP_N4: length 4.4
  TOP w0.102: v7(31.22,172.03) Q18.E
  TOP w0.254: Q18.E 32.55,171.71 C138.1 33.82,172.44 33.47,172.79 R151.2
DEPOP_N5: length 4.3
  TOP w0.102: R152.2 35.57,173.6 v2(35.23,173.93)
  TOP w0.254: Q13.B 34.2,173.46 R151.1 R152.2
  BOTTOM w0.102: v3(36.12,173.81) 35.36,173.81 v2(35.23,173.93)
DIMM_CA_CPU_VREF: length 88
  TOP w0.254: CPU.AB40 142.3,112.05 145.96,115.7 157.33,115.7 168.98,104.05 168.98,102.64 175.65,95.98 178.51,95.98 179.55,94.94 179.55,93.03 v2(179.17,92.65) ; R435.1 C384.1 181.3,61.38 v2(181.71,61.79)
  BOTTOM w0.254: v2(179.17,92.65) 180.06,91.76 v3(180.63,91.76) 181.27,91.76 184.44,88.59 184.44,64.52 v2(181.71,61.79)
DIMM_DQ_B: length 5.2
  TOP w0.102: v2(188.67,55.52) 188.79,55.4 R454.2
  TOP w0.254: R454.2 R453.1 C400.1 R450.1
  BOTTOM w0.102: v3(189.64,55.52) v2(188.67,55.52)
DIMM_DQ_CPU_VREF_A: length 47
  TOP w0.254: TP5.1 175.68,94.37 167.84,102.2 167.84,103.61 156.9,114.56 146.57,114.56 143,110.99 CPU.AC40
DIMM_DQ_CPU_VREF_B: length 89.1
  TOP w0.254: v2(187.65,59.73) C387.1 R445.1 ; v2(177.33,95.19) 175.64,95.19 168.4,102.43 168.4,103.84 157.13,115.12 146.2,115.12 142.53,111.45 141.93,111.45 141.48,110.99 CPU.AC39
  BOTTOM w0.254: v2(187.65,59.73) 187.65,60.87 185.01,63.51 185.01,88.84 v3(179.24,94.62) 178.66,95.19 v2(177.33,95.19)
DIMM_S5: length 11
  TOP w0.203: C482.1 134.71,28.98 134.04,28.98 133.6,28.55 U32.6
  TOP w0.254: Q50.D 141.07,28.77 140.16,29.69 140.16,29.86 v1(139.8,30.22) 139.47,30.22 139.17,29.91 138.58,29.91 138.07,30.42 R487.1 137.34,29.9 135.63,29.9 C482.1
DIMM_VRCA_A: length 5.5
  TOP w0.254: R440.2 R437.1 188.41,60.46 v2(186.46,60.46) 186.07,60.08 R436.1
  BOTTOM w0.102: v3(185.59,60.46) v2(186.46,60.46)
DIMM_VREF_CA_A: length 18.1
  TOP w0.254: DIMM2.146 179.3,46.36 180.57,47.63 180.57,49.6 182.25,51.28 C413.1 C403.1 182.47,54.9 C397.1 C394.1 182.25,57.44 R435.2 183.05,59.57 183.55,60.08 R436.2
DIMM_VREF_DQ_B: length 26.2
  TOP w0.254: R445.2 R450.2 186.16,56.84 185.78,57.22 C395.1 C398.1 185.33,54.9 C404.1 C414.1 185.11,53.19 181.14,49.22 181.14,41.6 178.34,38.8 DIMM1.146
DISPA_BCLK: length 83
  TOP w0.102: R311.1 46.9,112.17 47.78,113.05 47.78,115.88 50.74,118.84 v1(52.45,118.84) 53.05,119.44 54.64,119.44 55.27,120.07 59.63,120.07 63.42,116.27 70.63,116.27 72.85,114.06 72.85,109.95 73.68,109.11 74.74,108.06 76.82,108.06 80.32,111.55 80.32,116.99 85.07,121.75 91.44,121.75 95.62,117.57 101.52,117.57 102.07,117.02 105.5,117.02 106.05,116.48 CPU.V3
DISPA_BCLK_R: length 12.9
  TOP w0.089: PCH1.AM2 44.33,99.5 43.92,99.91 43.92,100.11 44.13,100.33 44.13,104.87 44.29,105.03 44.29,105.69
  TOP w0.102: R311.2 46.9,110.22 v1(46.63,109.95) 46.63,109.67 44.29,107.32 44.29,105.69
DISPA_SDI: length 73.8
  TOP w0.089: PCH1.AN2 43.85,99.72 43.66,99.91 43.66,100.13 43.93,100.4 43.93,104.95 44.06,105.08 44.06,105.69
  TOP w0.102: 44.06,105.69 44.06,107.54 45.57,109.05 45.57,110.19 46.39,111.02 46.39,112.02 47.52,113.15 47.52,116.07 50.85,119.4 v1(51.21,119.4) 51.47,119.66 54.42,119.66 55.06,120.3 59.77,120.3 63.56,116.5 70.75,116.5 73.1,114.15 73.1,110.01 74.83,108.29 76.73,108.29 80.09,111.64 80.09,117.09 84.21,121.21 R284.2
DISPA_SDI_R: length 21.4
  TOP w0.102: CPU.U1 102.21,117.39 101.8,117.8 95.73,117.8 91.54,121.99 85.67,121.99 R284.1
DISPA_SDO: length 81.2
  TOP w0.102: R312.1 48.11,111.99 48.11,115.77 50.65,118.31 53.21,118.31 v1(53.75,118.84) 54.42,118.84 55.42,119.84 59.53,119.84 63.32,116.05 70.54,116.05 72.62,113.96 72.62,109.85 74.64,107.83 76.92,107.83 80.54,111.45 80.54,116.9 85.17,121.52 91.34,121.52 95.52,117.34 101.3,117.34 101.82,116.82 104.71,116.82 105.05,116.48 CPU.V2
DISPA_SDO_R: length 12.5
  TOP w0.089: 44.54,105.69 44.54,105 44.39,104.85 44.39,100.15 PCH1.AM1
  TOP w0.102: 44.54,105.69 44.54,107.15 47.98,110.59 R312.2
DMI_RX_N0: length 72.7
  TOP w0.089: CPU.Y4 107.19,114.65 107.19,114.69 106.66,115.22 101.51,115.22 100.51,116.22 97.38,116.22 ; PCH1.C27 58.92,87.39 59.07,87.54 59.53,87.54 59.73,87.33 60.81,87.33 61.1,87.63 61.1,88.01 v4(60.9,88.21)
  TOP w0.102: 97.38,116.22 95,116.22 90.89,120.34 85.57,120.34 81.66,116.43 81.66,110.99 75.53,104.86 75.53,102.35 v7(75.2,102.02)
  BOTTOM w0.102: v4(60.9,88.21) 61.18,88.49 61.18,91.06 61.84,91.71 62.95,91.71 63.77,92.54 67.62,92.54 75.39,100.31 75.39,101.83 v7(75.2,102.02)
DMI_RX_N1: length 74.3
  TOP w0.089: PCH1.B28 59.33,86.81 59.45,86.69 61.46,86.69 62.54,87.76 62.54,88.98 62.87,89.31 62.87,90.13 62.61,90.38 62.32,90.38 v4(62.08,90.62) ; 97.38,115.51 100.18,115.51 100.25,115.44 101.02,114.67 105.61,114.67 106,114.29 107.63,114.29 108.1,113.81 CPU.AA5
  TOP w0.102: v7(76.54,103.45) 76.76,103.66 76.76,105.1 82.35,110.69 82.35,116.15 85.85,119.65 90.59,119.65 94.73,115.51 97.38,115.51
  BOTTOM w0.102: v4(62.08,90.62) 62.36,90.34 62.72,90.34 64.22,91.84 67.93,91.84 76.78,100.69 76.78,103.21 v7(76.54,103.45)
DMI_RX_N2: length 72.4
  TOP w0.089: v7(63.98,88.21) 63.78,88.21 63.6,88.03 63.6,87.49 62.27,86.16 59.42,86.16 59.28,86.29 PCH1.B29 ; CPU.AB3 106.63,112.82 106.69,112.88 106.69,113.09 106.62,113.16 105.98,113.16 105.91,113.09 105.38,113.09 104.52,113.95 100.43,113.95 99.74,114.64 97.47,114.64 97.47,114.63 97.41,114.63 97.4,114.62 97.38,114.62
  TOP w0.102: 97.38,114.62 94.25,114.62 90.11,118.76 86.22,118.76 83.24,115.78 83.24,110.28 78.36,105.41 78.36,105.12 78.56,104.92 v2(78.8,104.92)
  BOTTOM w0.102: v7(63.98,88.21) 63.8,88.21 63.7,88.31 63.7,89.95 64.68,90.94 68.3,90.94 78.46,101.1 78.46,104.82 78.57,104.92 v2(78.8,104.92)
DMI_RX_N3: length 73.2
  TOP w0.089: 63.75,86.28 63.74,86.27 63.74,86.26 63.73,86.26 63.4,85.92 59.33,85.92 PCH1.B30 ; 97.38,114.14 99.53,114.14 100.06,113.61 104.37,113.61 105.52,112.45 107.65,112.45 107.83,112.26 107.83,112 107.93,111.91 CPU.AC5
  TOP w0.102: 97.38,114.14 94.05,114.14 89.94,118.26 86.39,118.26 83.72,115.58 83.72,110.01 79.72,106.01 79.72,103.78 v7(79.39,103.45) ; 63.75,86.28 64.75,87.28 64.75,89.24 v2(64.47,89.51)
  BOTTOM w0.102: v2(64.47,89.51) 64.75,89.79 64.75,90.02 65.16,90.43 68.49,90.43 79.65,101.59 79.65,103.18 v7(79.39,103.45)
DMI_RX_P0: length 72.7
  TOP w0.089: PCH1.B27 59.27,87.35 59.45,87.35 59.65,87.14 60.89,87.14 61.29,87.55 61.29,88.03 61.47,88.21 v7(61.67,88.21) ; 97.38,116.02 97.4,116.02 97.41,116.03 97.47,116.03 97.47,116.03 100.43,116.03 101.43,115.03 106.58,115.03 106.71,114.9 106.71,114.73 106.63,114.65 CPU.Y3
  TOP w0.102: 97.38,116.02 94.92,116.02 90.81,120.13 85.65,120.13 81.86,116.35 81.86,110.91 75.73,104.77 75.73,102.06 75.77,102.02 v2(76.06,102.02)
  BOTTOM w0.102: v7(61.67,88.21) 61.39,88.49 61.39,90.97 61.92,91.51 63.03,91.51 63.86,92.33 67.7,92.33 75.59,100.23 75.59,101.75 75.87,102.02 v2(76.06,102.02)
DMI_RX_P1: length 74.3
  TOP w0.089: CPU.AA4 107.62,113.73 107.71,113.82 107.71,113.93 107.55,114.1 105.92,114.1 105.53,114.48 100.94,114.48 100.1,115.32 97.46,115.32 97.45,115.31 97.38,115.31 ; PCH1.A28 59.63,86.88 61.38,86.88 62.34,87.84 62.34,89.06 62.68,89.39 62.68,90.05 62.54,90.19 62.18,90.19 62,90.01 62,89.76 v7(62.08,89.68)
  TOP w0.102: 97.38,115.31 94.64,115.31 90.5,119.45 85.93,119.45 82.55,116.07 82.55,110.6 76.96,105.01 76.96,103.65 77.17,103.45 v2(77.41,103.45)
  BOTTOM w0.102: v7(62.08,89.68) 62.08,90.04 62.18,90.14 62.8,90.14 64.3,91.64 68.02,91.64 76.99,100.61 76.99,103.29 77.14,103.45 v2(77.41,103.45)
DMI_RX_P2: length 72.5
  TOP w0.089: v4(63.21,88.21) 63.41,88.01 63.41,87.57 62.19,86.35 59.53,86.35 59.37,86.52 58.95,86.52 58.73,86.29 PCH1.C29 ; CPU.AB4 107.19,112.87 106.7,113.35 105.9,113.35 105.83,113.28 105.46,113.28 104.6,114.14 100.51,114.14 99.82,114.83 97.38,114.83
  TOP w0.102: 97.38,114.83 94.34,114.83 90.2,118.97 86.13,118.97 83.03,115.87 83.03,110.37 78.16,105.49 78.16,105.14 v7(77.94,104.92)
  BOTTOM w0.102: v7(77.94,104.92) 78.26,104.61 78.26,101.18 68.22,91.14 64.6,91.14 63.49,90.04 63.49,88.49 v4(63.21,88.21)
DMI_RX_P3: length 73.2
  TOP w0.089: 63.89,86.14 63.88,86.13 63.87,86.13 63.48,85.73 59.65,85.73 PCH1.A30 ; CPU.AC4 107.52,111.91 107.64,112.03 107.64,112.18 107.57,112.26 105.45,112.26 104.29,113.42 99.99,113.42 99.45,113.95 97.47,113.95 97.47,113.94 97.41,113.94 97.4,113.94 97.38,113.94
  TOP w0.102: v2(80.25,103.45) 80,103.45 79.92,103.52 79.92,105.92 83.92,109.92 83.92,115.5 86.48,118.05 89.85,118.05 93.97,113.94 97.38,113.94 ; 63.89,86.14 64.95,87.19 64.95,89.4 65.06,89.51 v7(65.33,89.51)
  BOTTOM w0.102: v2(80.25,103.45) 79.99,103.45 79.86,103.32 79.86,101.51 68.58,90.23 65.24,90.23 64.95,89.93 64.95,89.68 65.11,89.51 v7(65.33,89.51)
DMI_TX_N0: length 75
  TOP w0.089: v4(55.08,86.95) 54.88,86.95 54.67,87.16 PCH1.L27 ; 97.38,113.25 99.19,113.25 99.56,112.88 104.04,112.88 104.85,112.07 104.85,111.99 104.76,111.91 CPU.AC1
  TOP w0.102: 97.38,113.25 93.68,113.25 89.59,117.34 86.74,117.34 84.61,115.21 84.61,109.48 81.13,106 81.13,105.05 81.24,104.93 v7(81.5,104.93)
  BOTTOM w0.089: 60.43,87.19 60.41,87.19 60.4,87.2 60.04,87.2 58.01,89.23 56.12,89.23 54.79,87.91 54.79,87.06 54.91,86.95 v4(55.08,86.95)
  BOTTOM w0.102: 60.43,87.19 66.56,87.19 81.19,101.83 81.19,104.83 81.29,104.93 v7(81.5,104.93)
DMI_TX_N1: length 66.3
  TOP w0.089: 98.99,112.57 99,112.57 99.24,112.32 103.1,112.32 104.09,111.33 105.63,111.33 105.75,111.21 105.75,111.06 105.69,110.99 CPU.AD2 ; v4(57.36,87.99) 57.72,88.34 PCH1.E24
  TOP w0.102: v2(82.92,103.4) 82.69,103.4 82.59,103.51 82.59,106.24 86.32,109.97 89.81,109.97 92.41,112.57 98.99,112.57
  BOTTOM w0.089: 60.43,86.49 60.41,86.49 60.4,86.5 59.73,86.5 59.1,87.13 58.59,87.13 58.01,87.7 58.01,88.33 57.82,88.52 57.11,88.52 56.97,88.38 56.97,88.16 57.14,87.99 v4(57.36,87.99)
  BOTTOM w0.102: 60.43,86.49 66.9,86.49 82.59,102.18 82.59,103.29 82.7,103.4 v2(82.92,103.4)
DMI_TX_N2: length 64.1
  TOP w0.089: 97.38,111.85 97.4,111.85 97.41,111.86 98.76,111.86 98.88,111.74 102.03,111.74 103.41,110.36 104.12,110.36 104.17,110.41 104.68,110.41 104.78,110.31 104.78,110.13 104.72,110.08 CPU.AE1 ; PCH1.G27 56.96,87.3 v4(56.6,86.95)
  TOP w0.102: 97.38,111.85 92.69,111.85 90.04,109.21 86.56,109.21 84.25,106.9 84.25,104.6 v2(84.58,104.27)
  BOTTOM w0.089: v4(56.6,86.95) 56.8,86.95 56.92,86.83 56.92,86.48 57.12,86.28 58.87,86.28 59.35,85.8 60.4,85.8 60.41,85.79 60.43,85.79
  BOTTOM w0.102: 60.43,85.79 67.19,85.79 84.25,102.85 84.25,103.94 v2(84.58,104.27)
DMI_TX_N3: length 68
  TOP w0.089: 98.48,111.37 98.5,111.37 98.51,111.36 101.82,111.36 103.25,109.92 104.01,109.92 104.22,109.72 105.74,109.72 105.93,109.53 105.93,109.3 106.07,109.16 CPU.AF3 ; PCH1.L29 54.67,86.08 54.32,85.73 v4(54.32,85.52)
  TOP w0.102: 98.48,111.37 92.88,111.37 90.12,108.6 86.64,108.6 85.73,107.69 85.73,105.11 v7(85.52,104.91)
  BOTTOM w0.089: 60.43,85.29 60.41,85.29 60.4,85.29 56.82,85.29 55.85,86.26 54.84,86.26 54.32,85.73 v4(54.32,85.52)
  BOTTOM w0.102: v7(85.52,104.91) 85.7,104.73 85.7,104.73 85.7,103.57 67.42,85.29 60.43,85.29
DMI_TX_P0: length 75
  TOP w0.089: 97.38,113.45 97.4,113.45 97.41,113.45 97.47,113.45 97.47,113.44 99.27,113.44 99.63,113.07 104.12,113.07 105.04,112.15 105.04,111.99 105.13,111.91 CPU.AC2 ; v4(54.32,86.95) 53.91,87.35 PCH1.N27
  TOP w0.102: 97.38,113.45 93.76,113.45 89.67,117.54 86.65,117.54 84.4,115.3 84.4,109.57 80.92,106.09 80.92,105.17 v7(80.68,104.93)
  BOTTOM w0.089: v4(54.32,86.95) 54.6,87.23 54.6,87.98 56.04,89.42 58.09,89.42 60.12,87.39 60.4,87.39 60.41,87.39 60.43,87.39
  BOTTOM w0.102: v7(80.68,104.93) 80.99,104.63 80.99,101.91 66.47,87.39 60.43,87.39
DMI_TX_P1: length 66.3
  TOP w0.089: CPU.AD3 106.12,110.99 105.94,111.17 105.94,111.29 105.71,111.52 104.17,111.52 103.18,112.51 99.32,112.51 99.07,112.76 99.02,112.76 99.01,112.77 98.99,112.77 ; PCH1.G24 56.96,88.34 v4(56.6,87.99)
  TOP w0.102: 98.99,112.77 92.32,112.77 89.73,110.18 86.24,110.18 82.39,106.33 82.39,103.73 v7(82.06,103.4)
  BOTTOM w0.089: 60.43,86.7 60.41,86.7 60.4,86.69 59.81,86.69 59.18,87.32 58.66,87.32 58.2,87.78 58.2,88.41 57.9,88.72 57.03,88.72 56.78,88.46 56.78,88.17 v4(56.6,87.99)
  BOTTOM w0.102: 60.43,86.7 66.82,86.7 82.39,102.26 82.39,103.07 v7(82.06,103.4)
DMI_TX_P2: length 64.1
  TOP w0.089: PCH1.E26 57.53,87.32 57.53,87.11 v4(57.36,86.94) ; CPU.AE2 105.1,110.08 104.97,110.21 104.97,110.39 104.76,110.6 104.09,110.6 104.04,110.55 103.49,110.55 102.11,111.93 98.96,111.93 98.84,112.05 97.41,112.05 97.4,112.06 97.38,112.06
  TOP w0.102: 97.38,112.06 92.6,112.06 89.96,109.42 86.48,109.42 84.05,106.99 84.05,104.6 v7(83.72,104.27)
  BOTTOM w0.089: v4(57.36,86.94) 57.11,86.69 57.11,86.56 57.2,86.47 58.95,86.47 59.43,85.99 60.4,85.99 60.41,86 60.43,86
  BOTTOM w0.102: 60.43,86 67.11,86 84.05,102.94 84.05,104.13 83.91,104.27 v7(83.72,104.27)
DMI_TX_P3: length 68
  TOP w0.089: 98.48,111.16 98.5,111.16 98.51,111.17 101.74,111.17 103.17,109.73 103.93,109.73 104.14,109.53 105.66,109.53 105.74,109.45 105.74,109.24 105.66,109.16 CPU.AF2 ; v4(55.08,85.52) 55.08,85.87 PCH1.K29
  TOP w0.102: 98.48,111.16 92.97,111.16 90.2,108.4 86.72,108.4 85.93,107.6 85.93,105.12 86.14,104.91 v7(86.34,104.91)
  BOTTOM w0.089: v4(55.08,85.52) 54.91,85.52 54.74,85.69 54.74,85.88 54.92,86.06 55.78,86.06 56.74,85.1 60.4,85.1 60.41,85.09 60.43,85.09
  BOTTOM w0.102: 60.43,85.09 67.5,85.09 85.9,103.49 85.9,104.64 86.17,104.91 v7(86.34,104.91)
DP_AUX_N: length 3.7
  TOP w0.102: U4.3 107.01,193.18 106.91,193.08 106.91,192.78 106.4,192.27 105.56,192.27 105.17,191.88 105.17,191.61 105.42,191.36 C48.2
DP_AUX_P: length 3.8
  TOP w0.102: C47.2 104.72,191.36 104.97,191.61 104.97,191.97 105.47,192.47 106.32,192.47 106.71,192.86 106.71,193.03 106.61,193.13 U4.2
DP_CTRLCLK: length 21.1
  TOP w0.089: v6(39.41,98.34) 39.69,98.07 PCH1.BA5
  TOP w0.102: v2(35.92,111.16) 35.92,111.61 R302.1
  BOTTOM w0.102: v2(35.92,111.16) 35.92,110.81 33.69,108.59 33.69,106.28 35.15,104.82 v3(35.15,104.31) 35.56,103.9 38.99,103.9 40.34,102.56 40.34,100.3 39.57,99.54 39.57,98.5 v6(39.41,98.34)
DP_CTRLDATA: length 22.1
  TOP w0.089: v6(39.05,98.95) 38.92,98.83 PCH1.BC4
  TOP w0.102: v2(35.15,110.88) 35.15,111.49 36.84,113.17 R301.1
  BOTTOM w0.102: v6(39.05,98.95) 39.05,99.44 40.06,100.45 40.06,102.48 38.9,103.64 35.01,103.64 34.57,104.08 34.57,104.98 33.44,106.11 33.44,109.23 v3(34.06,109.85) 35.09,110.88 v2(35.15,110.88)
DP_PWROK1: length 5.8
  TOP w0.102: R573.2 138.72,10.39 R581.1 C570.1 R582.1 142.01,10.39 v2(142.16,10.23)
  BOTTOM w0.102: v3(141.25,10.31) 142.09,10.31 v2(142.16,10.23)
DP_PWROK1_1: length 6.6
  TOP w0.102: v2(145.53,11.31) Q68.B 144.44,11.82 144.06,12.2 141.45,12.2 141.07,11.82 R582.2
  BOTTOM w0.102: v2(145.53,11.31) 145.54,11.32 v3(146.41,11.32)
DP_PWROK1_2: length 9.8
  TOP w0.102: R585.2 138.11,9.92 141.73,9.92 142.63,9.02 Q68.C v2(144.53,9.02) Q69.B
  BOTTOM w0.102: v2(144.53,9.02) 144.21,9.02 v3(143.66,9.57)
DP_TX_N0: length 2.9
  TOP w0.102: U4.6 108.21,193.11 108.1,193.01 108.1,192.7 108.92,191.89 108.92,191.56 109.11,191.36 C51.2
DP_TX_N1: length 4.3
  TOP w0.102: U4.8 109.01,193.2 108.92,193.11 108.92,192.93 109.32,192.52 110.57,192.52 111.33,191.76 111.33,191.53 111.5,191.36 C53.2
DP_TX_P0: length 2.9
  TOP w0.102: U4.5 107.81,193.13 107.9,193.03 107.9,192.62 108.71,191.81 108.71,191.56 108.52,191.36 C50.2
DP_TX_P1: length 4.3
  TOP w0.102: U4.7 108.61,193.21 108.71,193.11 108.71,192.85 109.24,192.32 110.48,192.32 111.13,191.68 111.13,191.53 110.95,191.36 C52.2
DPG: length 8.3
  TOP w0.508: 140.31,198.95 139.17,198.95 v2(138.91,198.7)
  BOTTOM w0.508: v2(138.91,198.7) 138.41,198.19 v2(138.41,195.9) v3(138.41,194.18) v2(138.41,192.09)
DPVGA_DDCCLK: length 2.2
  TOP w0.102: U4.15 110.44,196.46 111.02,197.05 R22.1
DPVGA_DDCSDA: length 2.5
  TOP w0.102: R21.1 111.29,198.13 v1(110.57,197.4) 110.02,196.86 U4.16
DPVGA_HPD: length 135.5
  TOP w0.089: 42.04,105.69 42.04,103.24 40.97,102.18 40.97,100.44 41.14,100.28 41.14,99.17 PCH1.AW4
  TOP w0.102: U4.32 105.03,194.06 R37.1 102.69,191.71 v2(102.59,191.71) ; 42.04,105.69 42.04,108.35 43.08,109.39 43.08,113.3 43.71,113.94 v3(43.71,116.91) 48.07,121.27 52.64,121.27 54.33,122.95 56.45,122.95 v2(57.39,122.01)
  BOTTOM w0.102: v2(102.59,191.71) 102.59,188.6 102.97,188.22 102.97,180.66 91.21,168.9 90.58,168.9 88.56,166.88 88.56,164.6 86.02,162.06 83.92,162.06 77.71,155.85 73.88,155.85 71.11,153.08 68.34,153.08 65.85,150.59 64.75,150.59 57.05,142.89 57.05,122.36 v2(57.39,122.01)
DPWROK: length 318.6
  TOP w0.089: PCH1.AV11 41.39,95.44 v4(41.11,95.71)
  TOP w0.102: v2(143.23,6.42) 143.23,6.93 144.64,8.34 146.7,8.34 146.81,8.45 146.81,10.01 147.04,10.23 Q69.C 147.68,11.31 148.35,11.98 148.35,16.93 150.12,18.7 158.5,18.7 160.43,20.63 160.43,23.36 161.39,24.33 164.28,24.33 R518.1 165.3,24.45 166.95,24.45 C507.1 168.47,24.71 168.98,24.71 169.19,24.5 U35.14 ; v2(13.31,76.46) 13.71,76.46 14.36,77.11 17.24,77.11 22.14,82.01 R367.1 22.68,82.69 22.68,84.96 C353.1 22.14,86.06 v2(22.35,86.28)
  BOTTOM w0.089: v4(41.11,95.71) 40.67,96.16 39.5,96.16 39.19,95.85 36.16,95.85 31.26,100.76
  BOTTOM w0.102: v2(143.23,6.42) 142.48,7.17 v3(142.44,7.17) 140.08,7.17 139.38,7.87 131.63,7.87 130.93,7.17 118.95,7.17 118.59,7.52 98.98,7.52 95.01,3.56 82.59,3.56 81.74,4.41 69.32,4.41 66.3,7.43 62,7.43 58.04,11.4 57.56,11.4 56.74,12.21 56.74,12.82 54.71,14.85 43.87,14.85 42.32,13.3 35.88,13.3 30.38,7.8 26.84,7.8 25.87,8.77 22.95,8.77 21.03,6.85 19.9,6.85 19.9,6.85 17.88,6.85 16.7,8.03 15.28,8.03 12.21,4.96 9.57,4.96 6.17,8.36 6.17,8.36 3.56,10.97 3.56,47.53 6.83,50.81 6.83,56.84 12.68,62.68 12.68,67.44 13.46,68.23 13.46,69.09 14.22,69.85 14.22,75.19 13.31,76.1 v2(13.31,76.46) ; 31.26,100.76 30.35,101.67 26.91,101.67 22.35,97.11 v2(22.35,86.28)
DQ_REF_B_RC: length 2.9
  TOP w0.102: R439.1 v2(185.55,58.19)
  TOP w0.254: R439.1 C387.2
  BOTTOM w0.102: v2(185.55,58.19) 185.23,58.51 v3(184.76,58.51)
DRAM_RESET_L: length 225.9
  TOP w0.089: PCH1.BC14 38.93,93.82 38.69,93.58 38.22,93.58 38.16,93.53 38.12,93.48 36.05,93.48 34.46,91.89 34.46,88.7 32.92,87.16 32.92,86.35 32.02,85.45
  TOP w0.102: v2(23.83,62.59) 25.49,60.93 28.29,60.93 28.67,60.55 30.02,60.55 31.14,61.66 33.99,61.66 37.69,57.96 v2(37.69,55.7) ; v2(94.72,27.06) 93.57,27.06 91.61,25.09 v2(91.54,25.09) ; R473.1 R472.2 C453.2 R471.1 126.5,33.63 v2(125.39,32.52) ; 32.02,85.45 30.37,83.8 29.4,83.8 29.31,83.71 28.57,83.71 27.74,82.88 27.74,82.27 27.72,82.25 27.72,82.24 24.69,79.22 24.69,77.74 24.3,77.35 24.3,70.68 23.81,70.19 23.81,68.76 23.09,68.03 v2(23.09,67.56)
  BOTTOM w0.102: v2(125.39,32.52) 125.2,32.71 118.97,32.71 117.32,34.36 106.1,34.36 103.96,32.23 103.96,28.97 102.06,27.07 v3(96.03,27.07) 96.01,27.06 v2(94.72,27.06) ; v2(91.54,25.09) 91.35,25.28 54.62,25.28 53.03,23.69 41.35,23.69 40.97,24.07 33.88,24.07 33.63,23.82 32.74,23.82 31.5,22.58 30.04,22.58 27.42,19.96 20.84,19.96 19.08,21.72 19.08,32.51 22.86,36.29 22.86,39.07 23.56,39.77 23.56,45.12 25.57,47.13 25.57,48.9 25.95,49.28 29.25,49.28 34.77,54.81 36.81,54.81 v2(37.69,55.7) ; v2(23.09,67.56) 23,67.47 23,64.91 23.83,64.09 v2(23.83,62.59)
DVI_CTRLDATA: length 15.6
  TOP w0.089: v6(38.46,98.37) 38.43,98.34 PCH1.BD6
  TOP w0.102: v4(33.3,105) 33.19,105.11 33.19,106.91 R322.1
  BOTTOM w0.102: v4(33.3,105) 33.3,104.95 34.85,103.4 38.74,103.4 39.8,102.33 39.8,100.67 38.3,99.17 v3(38.3,99.13) 38.3,98.52 v6(38.46,98.37)
DVI_HPD: length 10.6
  TOP w0.089: PCH1.AY2 40.33,99.61 40.6,99.88 40.6,100.23 38.75,102.08 v4(38.2,102.08) 38.02,102.25 38.02,103.27 38.71,103.96 39.73,103.96 40.93,105.16 40.93,105.69
  TOP w0.102: R326.2 40.93,105.69
  BOTTOM w0.102: v3(39.04,101.92) 38.35,101.92 v4(38.2,102.08)
ECIO_A3VSB: length 12.5
  TOP w0.305: U35.96 186.25,29.75 186.47,29.98 186.47,30.36
  TOP w0.508: L25.1 191.68,34.8 191.17,35.31 188.89,35.31 C451.2 187.17,34.23 C454.2 186.03,32.53 v2(186.47,32.09) 186.47,30.36
  BOTTOM w0.102: v3(186.47,32.91) v2(186.47,32.09)
EDP_HPD: length 11.2
  TOP w0.089: PCH1.BD7 38.29,97.12 38.1,97.32 37.38,97.32 33.44,101.25 33.44,103.96 v4(33.28,104.11) R329.1
  BOTTOM w0.102: v3(32.59,104.56) 33.04,104.11 v4(33.28,104.11)
EDP_RCOMP: length 4.3
  TOP w0.203: 112.95,120.9 112.52,120.9 111.76,121.66 CPU.M9
  TOP w0.305: R289.1 114.21,119.64 112.95,120.9
EUP_SW_N1: length 7.5
  TOP w0.254: Q39.B 11.06,58.17 C389.2 10.8,59.35 v2(10.52,59.63) 10.33,59.82 9.56,59.82 9.18,59.44 9.18,58.27 R443.1
  BOTTOM w0.102: v3(10.44,58.49) 10.44,59.56 v2(10.52,59.63)
EUP_SW_N2: length 8.2
  TOP w0.102: v2(9.88,56.63) 10.59,57.35 R448.1
  TOP w0.254: R448.1 13.58,57.35 13.77,57.16 Q39.C 14.45,57.79 15.09,58.43 R441.2
  BOTTOM w0.102: v3(9.65,55.77) 9.65,56.41 v2(9.88,56.63)
EUP_SW_N3: length 136.3
  TOP w0.102: R539.2 97.52,19.69 97.92,20.08 v2(97.92,20.52) ; v2(19.41,57.28) 19.41,57.03 24.01,52.42 24.01,49.76 v2(24.93,48.84) ; R441.1 16.83,59.22 17.42,59.81 19.23,59.81 19.69,59.35 C390.1 19.72,58.39 R444.2 20.8,58.92 v2(20.49,59.24)
  BOTTOM w0.102: v2(24.93,48.84) 24.93,46.92 23.25,45.25 23.25,39.85 22.58,39.17 22.58,36.47 18.77,32.66 18.77,21.6 20.71,19.65 27.62,19.65 30.26,22.29 33.3,22.29 34.77,23.77 40.95,23.77 41.28,23.44 53.21,23.44 54.74,24.97 90.74,24.97 91.26,24.45 92.43,24.45 96.19,20.69 v3(96.88,20.69) 97.74,20.69 v2(97.92,20.52) ; v2(19.41,57.28) 19.41,58.16 v2(20.49,59.24)
EUP_SW_N4: length 4.4
  TOP w0.102: R539.1 v2(95.57,20.51)
  TOP w0.254: Q58.G 95.29,18.99 95.57,19.28 R539.1 C535.2
  BOTTOM w0.102: v3(94.87,21.07) 95.43,20.51 v2(95.57,20.51)
EUP_SW_N5: length 10.9
  TOP w0.254: C386.2 27.29,59.4 v2(27.29,58.17) Q40.G 25.63,58.17 23.11,55.65 21.86,55.65 21.37,56.14 21.37,56.87 R444.1
  BOTTOM w0.102: v3(26.47,58.17) v2(27.29,58.17)
FAN_CTL1: length 75.1
  TOP w0.102: U35.6 171.5,27.7 172.12,28.33 172.12,29.28 v2(171.55,29.85) ; R361.2 v2(186.35,86.43) R362.1
  BOTTOM w0.102: v2(186.35,86.43) 187.11,85.67 v3(187.11,82.37) 186.7,81.96 186.7,64.86 190.35,61.21 190.35,60.24 184.86,54.75 184.86,53.13 182.41,50.68 182.41,35.5 179.62,32.71 176.89,32.71 174.49,30.31 172.01,30.31 v2(171.55,29.85)
FAN_CTL1_R: length 4.6
  TOP w0.102: CPU_FAN.4 191.36,86.43 R362.2
FAN_TAC1: length 76.2
  TOP w0.102: v2(167.3,28.96) 167.58,28.68 C488.1 167.62,28.1 U35.5 ; R363.2 v2(186.35,85.29) R364.2
  BOTTOM w0.102: v2(167.3,28.96) 167.36,28.96 168.33,29.93 170.18,29.93 170.92,30.66 174.34,30.66 176.74,33.06 179.47,33.06 182.06,35.65 182.06,50.83 184.51,53.28 184.51,54.89 188.82,59.21 188.82,61.1 186.35,63.57 v3(186.35,84.14) v2(186.35,85.29)
FAN_TAC1_R: length 7.8
  TOP w0.102: CPU_FAN.3 189.97,85.29 R364.1 R366.1 187.68,83.73 D17.P
FP_2: length 5.6
  TOP w0.508: R606.1 113.93,7.4 112.81,6.29 112.81,4.58 F_PANEL.11
FP_3: length 2.7
  TOP w0.102: R605.2 102.43,7.34 F_PANEL.6
FP_4: length 2.5
  TOP w0.508: R588.2 112.62,7.24 111.54,6.17 F_PANEL.12
FP_5: length 6
  TOP w0.102: Q67.E 116.62,6.29 115.86,5.53 114.4,5.53 F_PANEL.14
FP_PWRBTN_L: length 108.6
  TOP w0.102: U35.72 188.51,20.1 C534.2 188.41,19.44 v2(186.98,19.44) ; D24.3 108.34,11.02 107.93,10.61 v2(107.93,9.91) 107.93,9.47 108.5,8.9 108.5,8.36 R590.1 107.89,7.75 107.03,7.75 106.71,8.07 106.71,8.11 106.38,8.44 105.25,8.44 C582.1 R605.1
  BOTTOM w0.102: v2(186.98,19.44) 186.03,19.44 v3(185.59,19.88) 185.14,20.33 181.9,20.33 181.01,19.44 178.09,19.44 176.63,17.98 176.63,15.82 177.33,15.12 177.33,9.4 175.32,7.4 146.45,7.4 145.61,6.56 144.44,6.56 142.21,8.79 138.06,8.79 137.29,9.56 136.68,10.18 135.51,10.18 134.78,9.45 129.82,9.45 129.08,8.72 119.59,8.72 119.11,9.2 116.52,9.2 115.55,10.18 108.19,10.18 v2(107.93,9.91)
FP_RST_L: length 256
  TOP w0.089: PCH1.AW1 40.89,100.25 40.08,101.06 40.08,101.77 38.99,102.86 v2(38.58,102.86)
  TOP w0.102: C576.1 110.59,9.34 v2(110.47,9.47) ; C576.1 111.29,9.15 110.88,8.74 R592.2 ; C576.1 111.29,9.72 112.12,10.55 D25.3
  BOTTOM w0.089: 32.02,103.64 32.79,102.86 v2(38.58,102.86)
  BOTTOM w0.102: v2(110.47,9.47) 110.17,9.17 98.43,9.17 96.73,7.47 68.87,7.47 66.78,9.56 65.67,9.56 64.87,10.36 62.23,10.36 v3(61.8,9.92) 61.2,9.92 59.74,11.38 59.74,12.69 59.05,13.38 57.74,13.38 55.35,15.77 43.49,15.77 42.03,14.3 35.51,14.3 31.29,10.08 29.93,8.72 27.31,8.72 26.35,9.68 22.57,9.68 20.65,7.77 20.27,7.77 20.27,7.77 18.39,7.77 17.21,8.95 12.99,8.95 12.28,9.66 6.7,9.66 4.85,11.51 4.85,35.68 7.04,37.86 8.36,37.86 8.84,38.35 8.84,50.46 12.1,53.73 12.1,59.57 14.99,62.45 14.99,68.46 15.75,69.22 15.75,76.58 11.7,80.63 11.7,105.83 12.42,106.56 14.64,106.56 15.68,105.52 19.19,105.52 20.17,106.5 21.01,106.5 22.99,104.51 31.14,104.51 32.02,103.64
FRONT_JD: length 44.2
  TOP w0.254: AUDIO.23 48.65,200.03 46.34,200.03 43.92,197.61 43.92,193.74 45.06,192.6 45.06,189.39 43.35,187.67 43.35,186.29 42.96,185.91 42.96,183.86 42,182.89 42,180.06 40.65,178.71 27.49,178.71 R115.2
FRONT_L: length 47
  TOP w0.254: R48.1 34.52,192.47 v2(34.71,192.66) 34.71,192.98 30.95,196.74 30.95,197.63 28.2,200.38 23.95,200.38 23.03,201.3 23.03,203.14 23.29,203.41 Q4.C1 ; v2(52.43,183.84) 53.03,183.84 R94.1 53.38,185.24 L11.1
  BOTTOM w0.254: v2(34.71,192.66) 41.58,192.66 46.09,188.16 51.09,188.16 v3(53.44,185.81) 53.51,185.74 53.51,184.28 53.06,183.84 v2(52.43,183.84)
FRONT_L1: length 21.2
  TOP w0.254: CODEC.35 16.46,187.74 v2(16.55,187.65)
  BOTTOM w0.254: EC1.1 33.96,186.51 28.02,186.51 26.88,187.65 v2(16.55,187.65)
FRONT_L2: length 3.8
  TOP w0.254: R48.2 34.98,190.28 EC1.2
FRONT_L_P: length 3.5
  TOP w0.254: Q4.B1 22.26,202.76 22.52,203.02 v3(22.52,204.29) 22.52,204.41 21.79,205.14 R7.2
FRONT_LL: length 20.5
  TOP w0.254: L11.2 53.33,187.01 C71.1 54.74,186.64 D5.2 55.65,187.89 57,189.24 57,193.34 55.52,194.82 51.36,194.82 AUDIO.24
FRONT_R: length 50.4
  TOP w0.254: L9.1 60.03,184.34 R96.1 59.16,184.85 v2(59.16,184.98) ; R47.1 33.44,191.97 33.82,192.35 v2(33.82,192.79) 33.82,193.15 30.44,196.53 30.44,197.42 27.99,199.87 23.74,199.87 22.33,201.28 22.33,202.11 Q4.C2
  BOTTOM w0.254: v2(33.82,192.79) 34.39,193.36 41.69,193.36 46.33,188.73 52.3,188.73 55.28,185.74 v3(56.87,185.74) 58.33,185.74 58.41,185.67 58.43,185.67 59.11,184.98 v2(59.16,184.98)
FRONT_R1: length 17.5
  TOP w0.254: v2(15.72,187.65) 15.88,187.81 CODEC.36
  BOTTOM w0.254: EC2.1 29.77,187.01 28.23,187.01 26.91,188.33 16.26,188.33 15.72,187.79 v2(15.72,187.65)
FRONT_R2: length 2.8
  TOP w0.254: R47.2 33.44,188.68 EC2.2
FRONT_R_P: length 3.6
  TOP w0.254: Q4.B2 24.3,202.76 24.55,203.02 24.55,203.9 24.3,204.16 v3(24.3,204.29) 24.3,204.67 24.84,205.21 R8.2
FRONT_RR: length 14.6
  TOP w0.254: AUDIO.21 55.84,195.22 57.55,193.51 D5.1 58.45,186.64 C69.1 59.87,187.03 L9.2
FW_CE_N: length 31.5
  TOP w0.102: R609.1 188.98,6.01 188.32,6.67 ROM1.1 188.32,9.66 187.78,10.19 184.35,10.19 v2(184.06,10.48) ; v2(181.01,18.48) 180.06,18.48 177.74,20.81 171.65,20.81 171.13,20.28 171.13,19.46 170.97,19.3 U35.27
  BOTTOM w0.102: v2(181.01,18.48) v3(181.01,17.02) 181.01,16.52 184.06,13.47 v2(184.06,10.48)
FW_HOLD_L: length 3.8
  TOP w0.102: ROM1.7 187.05,2.8 187.43,2.42 189.17,2.42 R613.1
FW_SCK: length 34.7
  TOP w0.102: R538.1 165.8,20.33 v1(165.66,20.19) 165.2,19.73 165.2,16.73 165.71,16.22 165.71,13.41 167.33,11.79 168.66,11.79 170,10.45 172.04,10.45 174.16,8.32 176.63,8.32 180.98,3.98 182,3.98 182.18,4.16 182.18,5.12 182.41,5.34 RN22.3 185.07,5.34 185.78,4.64 ROM1.6
FW_SCK_R: length 3.2
  TOP w0.102: U35.22 169.29,21.3 168.91,20.92 168.91,20.62 v1(168.53,20.24) 167.67,20.24 R538.2
FW_SI: length 33.8
  TOP w0.102: R534.1 165.39,21.53 164.95,21.09 164.95,15.99 v1(165.2,15.74) 165.38,15.56 165.38,13.42 167.23,11.56 168.57,11.56 169.91,10.22 171.94,10.22 174.07,8.1 176.48,8.1 180.82,3.75 182.35,3.75 182.79,4.2 RN22.1 184.19,4.77 184.51,4.45 ROM1.5
FW_SI_SH: length 2.8
  TOP w0.102: R534.2 v1(168.55,21.53) 168.72,21.7 U35.21
FW_SMBCLK: length 4.7
  TOP w0.102: R576.1 178.92,12.08 TP6.1 178.33,14.19 177.64,14.89 U35.48
FW_SMBDA: length 7.9
  TOP w0.102: R577.1 v2(180,12.32) ; v2(178.03,17.09) 178.03,15.8 U35.49
  BOTTOM w0.102: v2(178.03,17.09) 178.03,16.58 STP33.1 180.32,14.29 180.32,12.64 v2(180,12.32)
FW_SOUT: length 17.2
  TOP w0.102: v2(182.03,7.69) R589.1 182.98,6.99 182.79,6.8 RN22.7 ; v2(178.6,17.66) 177.33,17.66 176.44,16.77 U35.45
  BOTTOM w0.102: v2(178.6,17.66) 181.39,14.86 181.39,10.17 182.03,9.53 v3(182.03,9.28) v2(182.03,7.69)
FW_SOUT_SH: length 5.3
  TOP w0.102: R589.2 183.19,9.21 183.93,9.96 186.8,9.96 187.05,9.72 ROM1.2
FW_WP_L: length 4.8
  TOP w0.102: RN22.5 183.74,5.84 185.78,7.88 ROM1.3
GLAN_CLKN: length 77.5
  TOP w0.089: v4(57.58,98.89) 57.58,99.08 57.71,99.21 57.9,99.21 PCH1.D3
  TOP w0.102: U19.16 57.26,162.82 57.16,162.91 56.73,162.91 53.36,159.54 52.59,159.54 52.46,159.42 v2(52.46,159.21)
  BOTTOM w0.102: v2(52.46,159.21) 52.46,159.44 52.39,159.52 51.96,159.52 51.73,159.29 51.73,158.41 52.87,157.27 52.87,150.01 45.82,142.96 45.82,119.71 56.57,108.97 56.57,100.26 57.25,99.57 57.25,99.08 57.44,98.89 v4(57.58,98.89)
GLAN_CLKP: length 77.6
  TOP w0.089: v4(56.88,98.9) 57.48,99.5 PCH1.F2
  TOP w0.102: U19.15 57.29,163.22 57.19,163.11 56.64,163.11 53.28,159.75 52.79,159.75 v7(52.46,160.08)
  BOTTOM w0.102: v7(52.46,160.08) 52.11,159.72 51.87,159.72 51.52,159.37 51.52,158.32 52.67,157.18 52.67,150.09 45.62,143.05 45.62,119.63 56.36,108.88 56.36,100.18 57.05,99.49 57.05,99.07 v4(56.88,98.9)
GLAN_RX_N7: length 81.5
  TOP w0.089: v4(54.94,90.38) 54.67,90.11 PCH1.L22
  TOP w0.102: C183.2 55.29,158.41 55.29,158.07 54.7,157.49 54.13,157.49 v2(53.8,157.16)
  BOTTOM w0.102: v2(53.8,157.16) 54.15,157.51 54.46,157.51 54.86,157.11 54.86,151.3 46.32,142.75 46.32,119.91 57.06,109.17 57.06,100.65 58.27,99.45 58.27,98.62 55.27,95.62 55.27,90.71 v4(54.94,90.38)
GLAN_RX_P7: length 81.4
  TOP w0.089: PCH1.K22 55.43,90.05 v4(55.77,90.38)
  TOP w0.102: v7(53.8,158.02) 54.13,157.69 54.62,157.69 55.09,158.16 55.09,158.41 C182.2
  BOTTOM w0.102: v4(55.77,90.38) 55.47,90.67 55.47,95.54 58.47,98.54 58.47,99.53 57.26,100.74 57.26,109.25 46.52,120 46.52,142.67 55.07,151.22 55.07,157.19 54.55,157.71 54.1,157.71 v7(53.8,158.02)
GLAN_TX_N7: length 92.7
  TOP w0.089: v4(60.46,89.73) 60.25,89.52 60.25,89.09 59.93,88.77 59.37,88.77 59.37,88.77 59.34,88.77 59.32,88.79 58.9,88.79 58.61,89.08 PCH1.C23
  TOP w0.102: C171.2 53.33,162.88 53.07,162.88 v2(52.74,162.55)
  BOTTOM w0.102: v2(52.74,162.55) 52.41,162.88 52.16,162.88 51.91,162.63 51.91,162.04 55.93,158.01 55.93,151.09 47.22,142.38 47.22,120.27 58.27,109.21 58.27,101.66 58.76,101.18 58.76,100.38 59.69,99.45 59.69,97.89 58.9,97.1 57.95,97.1 56.12,95.27 56.12,94.01 59.13,91 59.7,91 60.25,90.45 60.25,89.94 v4(60.46,89.73)
GLAN_TX_P7: length 92.6
  TOP w0.089: v4(59.7,89.73) 59.89,89.73 60.06,89.57 60.06,89.17 59.85,88.96 59.45,88.96 59.45,88.96 59.42,88.96 59.4,88.98 59.15,88.98 59.05,89.08 PCH1.B23
  TOP w0.102: C169.2 53.32,163.09 52.88,163.09 52.74,163.23 v7(52.74,163.42)
  BOTTOM w0.102: v4(59.7,89.73) 59.89,89.73 60.05,89.88 60.05,90.37 59.61,90.8 59.04,90.8 55.92,93.92 55.92,95.35 57.87,97.3 58.82,97.3 59.49,97.97 59.49,99.37 58.56,100.3 58.56,101.09 58.07,101.58 58.07,109.13 47.02,120.19 47.02,142.46 55.73,151.17 55.73,157.93 51.7,161.96 51.7,162.71 52.08,163.09 52.55,163.09 52.74,163.28 v7(52.74,163.42)
GLED0: length 5.1
  TOP w0.102: Q64.C 97.38,9.34 96.88,8.83 R603.2 96.88,7.82 F_PANEL.2
GLED1: length 3.8
  TOP w0.102: F_PANEL.4 101.13,6.1 R604.2 101.13,8.39 101.58,8.83 Q65.C
GPD1: length 32.5
  TOP w0.089: PCH1.BB15 39.22,93.21 39.01,93 38.81,93 38.7,92.9 36.54,92.9 35.22,91.57 35.22,88.63 33.52,86.92 33.52,85.74 32.02,84.25
  TOP w0.102: 32.02,84.25 30.89,83.11 29.68,83.11 29.59,83.03 28.85,83.03 28.42,82.6 28.42,81.96 27.46,80.99 27.46,80.64 v1(27.18,80.36) 26.82,80.36 25.38,78.91 25.38,77.44 24.99,77.05 24.99,73.74 25.57,73.16 R397.1 24.99,71.79 24.99,70.08 R403.1
GPD10: length 66.6
  TOP w0.089: v4(40.37,93.89) 40.37,93.89 40.03,94.24 PCH1.BA13
  TOP w0.102: R385.1 20.12,72.71 v2(19.9,72.5) ; R432.2 24.88,62.97 24.34,63.5 24.15,63.7 19.58,63.7 v2(19.38,63.49)
  BOTTOM w0.089: 31.26,98.77 35.5,94.53 39.73,94.53 v4(40.37,93.89)
  BOTTOM w0.102: 31.26,98.77 29.88,100.15 27.79,100.15 24.94,97.3 24.94,86.91 22.68,84.65 22.68,83.1 v3(23.09,82.7) 23.09,81.45 20.49,78.85 20.49,77.13 19.66,76.31 19.66,72.74 v2(19.9,72.5) 20.24,72.15 20.24,70.49 18.54,68.79 18.54,64.33 v2(19.38,63.49)
GPP_B7: length 27.2
  TOP w0.089: PCH1.AT24 42.13,88.46 v4(41.63,87.96)
  TOP w0.102: v2(33.58,67.96) 33.79,67.75 R421.2
  BOTTOM w0.089: 34.95,75.01 34.95,76.02 34.39,76.57
  BOTTOM w0.102: v2(33.58,67.96) 33.31,68.23 33.31,71.15 v3(33.71,71.54) 34.95,72.79 34.95,75.01 ; v4(41.63,87.96) 41.22,87.55 40.16,87.55 39.57,86.96 38.41,86.96 36.53,85.08 35.92,85.08 35.05,84.22 35.05,81.65 34.39,80.99 34.39,76.57
GPP_B18: length 2.6
  TOP w0.089: v4(36.63,86.35) 37.03,86.35 37.08,86.4 37.45,86.4 37.52,86.47 38.04,86.47 38.08,86.52 PCH1.BD28
  BOTTOM w0.089: STP14.1 36.27,86 v4(36.63,86.35)
GPP_D4: length 8.5
  TOP w0.089: PCH1.AM44 44.14,78.87 44.48,78.53 44.48,76.76 41.82,74.1 v2(41.82,73.48) R387.2
  BOTTOM w0.102: v3(41.82,74.34) v2(41.82,73.48)
GPP_E0: length 11.6
  TOP w0.089: v2(45.19,73.37) 45.06,73.24 R389.1 ; PCH1.AG36 46.92,82.52 v4(46.59,82.86)
  BOTTOM w0.102: v2(45.19,73.37) 45.19,74.59 v3(45.11,74.67) 45.11,75.68 45.34,75.91 45.34,77.62 46.08,78.35 46.08,82.34 v4(46.59,82.86)
GPP_E1: length 12.7
  TOP w0.089: v4(46.55,83.64) PCH1.AG35 ; R388.1 v2(43.98,73.48)
  BOTTOM w0.102: v4(46.55,83.64) 45.82,82.91 45.82,78.97 v3(45.29,78.44) 44.93,78.09 44.93,76.04 44.45,75.56 44.45,73.94 v2(43.98,73.48)
GPP_E2: length 12.9
  TOP w0.089: v4(46.55,81.36) PCH1.AG39
  TOP w0.102: R407.1 44.23,70.05 v2(44.93,70.74)
  BOTTOM w0.102: v2(44.93,70.74) v3(44.93,71.95) 45.67,72.69 45.67,77.44 46.36,78.12 46.36,81.16 v4(46.55,81.36)
GPP_E3: length 15.8
  TOP w0.089: v4(47.56,83.32) 47.62,83.29 PCH1.AD35 ; 48.57,71.52 48.57,73.78 48.82,74.03 v4(48.82,74.11)
  TOP w0.102: 48.57,71.52 48.57,69.3 R411.1
  BOTTOM w0.102: v4(47.56,83.32) 48.36,82.52 48.36,76.14 v3(48.82,75.68) v4(48.82,74.11)
GPP_E4: length 13.6
  TOP w0.089: R391.1 49.06,73.49 v4(49.12,73.55) ; v4(48.65,84.98) 48.5,84.98 PCH1.AD31
  BOTTOM w0.102: v4(49.12,73.55) 49.45,73.88 49.45,75.86 48.65,76.66 v3(48.65,83.94) v4(48.65,84.98)
GPP_E9: length 17.2
  TOP w0.089: PCH1.AD43 48.17,79.16 47.94,78.93 47.94,78.63 47.97,78.6 47.97,78.58 47.97,76.55 47.07,75.64 47.07,71.52
  TOP w0.102: BIOS_WP.2 44.23,65.25 45.16,66.18 45.16,66.9 45.68,67.41 R422.1 47.07,68.08 47.07,71.52
GPP_E10: length 26.3
  TOP w0.089: 48.34,71.52 48.35,71.54 48.35,77.98 48.35,78.58 48.41,78.63 48.41,79.45 48.3,79.56 PCH1.AD42
  TOP w0.102: 48.34,71.52 48.34,67.61 47.98,67.25 47.98,63.62 45.64,61.28 45.64,60.32 46.1,59.86 46.1,58.99 R442.1 45.47,58.08 45.86,57.69 46.62,57.69 v1(46.97,57.35) Q42.B
GPP_F15: length 10.8
  TOP w0.089: PCH1.Y43 50.45,79.15 50.21,78.91 50.21,78.63 50.25,78.59 50.25,76.25 v7(50.02,76.02)
  TOP w0.102: v7(50.02,76.02) 49.84,75.83 49.84,70.07 R412.1
  BOTTOM w0.089: v3(50.85,75.79) 50.62,76.02 v7(50.02,76.02)
GPP_F16: length 47.9
  TOP w0.089: 49.57,74.67 49.57,76.24 50.04,76.71 50.04,77.54 49.45,78.12 49.45,79.01 49.71,79.27 49.96,79.27 50.24,79.55 50.24,80.03 PCH1.Y41
  TOP w0.102: 49.57,74.67 49.57,67.98 R423.1 48.21,66.62 48.21,63.26 46.15,61.21 v2(46.15,61.08) ; D20.1 v2(26.33,47.74)
  BOTTOM w0.102: v2(46.15,61.08) 43.97,61.08 v3(42.93,60.04) 37.39,54.5 34.87,54.5 29.05,48.68 28.26,48.68 27.33,47.74 v2(26.33,47.74)
GPP_G15: length 9.2
  TOP w0.089: PCH1.R41 52.85,80.17 52.43,79.74 52.43,77.54 51.84,76.95 v2(51.84,73.42) 51.79,73.37 R395.1
  BOTTOM w0.102: v3(51.82,74.31) 51.84,74.29 v2(51.84,73.42)
GPP_H2: length 56.5
  TOP w0.089: PCH1.BD32 38.47,84.73 38.08,84.33 38.08,84.09 37.37,83.38 37.22,83.38 36.5,82.66 36.5,80.04 34.47,78.01 34.47,73.72 33.6,72.86 33.6,72.1 33.02,71.52
  TOP w0.102: v7(14.28,65.96) 17.72,65.96 18.5,65.17 23.95,65.17 25.35,66.57 26.59,66.57 27.15,67.13 27.15,68.84 28.45,70.13 29.29,70.13 29.63,70.48 31.87,70.48 R401.1 32.82,71.32 33.02,71.52 ; R370.2 11.66,81.79 13.25,80.21 v2(13.25,78.05)
  BOTTOM w0.102: v2(13.25,78.05) 13.63,78.05 15.29,76.39 15.29,69.41 14.53,68.65 14.53,66.21 v7(14.28,65.96)
GPP_H12: length 5.5
  TOP w0.089: v7(37.26,81.78) 37.04,82 37.04,82.66 37.35,82.97 PCH1.BD35
  BOTTOM w0.089: STP20.1 35.54,80.16 37.16,81.78 v7(37.26,81.78)
GPP_H16: length 17.2
  TOP w0.089: PCH1.BD39 38.4,81.23 38.19,81.02 37.45,81.02 37.08,80.65 37.08,79.81 35.13,77.86 35.13,73.58 34.3,72.75 34.3,71.52
  TOP w0.102: RJ7.2 31.5,67.68 32.94,69.13 v1(32.94,69.18) 32.94,70.12 34.3,71.48 34.3,71.52
GPP_H17: length 21.1
  TOP w0.089: PCH1.BE34 37.58,83.19 37.3,83.19 36.7,82.58 36.7,79.97 34.67,77.94 34.67,73.66 33.83,72.82 33.83,71.77 33.58,71.52
  TOP w0.102: 33.58,71.52 32.3,70.24 30.09,70.24 v1(29.69,69.84) 29.34,69.49 29.34,68.2 RJ6.2
GPP_H18: length 20.7
  TOP w0.089: 33.99,71.52 34.06,71.6 34.06,72.78 34.9,73.62 34.9,77.9 36.89,79.89 36.89,80.73 38.08,81.92 38.08,82.01 38.22,82.15 38.63,82.15 38.93,82.45 PCH1.BC36
  TOP w0.102: RJ5.2 29.57,68.14 29.57,69.07 30.51,70.01 31.33,70.01 v1(31.73,69.61) 32.08,69.61 33.99,71.52
GPP_I3: length 19.7
  TOP w0.089: v6(40.11,98.97) 39.85,98.97 PCH1.BA4
  TOP w0.102: R309.1 v2(36.84,110.5)
  BOTTOM w0.102: v6(40.11,98.97) 40.56,99.43 40.56,103.22 v3(40.21,103.57) 39.65,104.13 36.17,104.13 33.92,106.38 33.92,108.44 35.98,110.5 v2(36.84,110.5)
GSPI1_MOSI: length 2.1
  TOP w0.089: v4(42.58,85.59) 42.23,85.95 PCH1.AT29
  BOTTOM w0.089: STP12.1 43.48,86.49 v4(42.58,85.59)
H_CATERR_L: length 4.7
  TOP w0.102: CPU.D13 114.96,128.82 114.96,128.19 114.68,127.91 v7(114.04,127.91)
  BOTTOM w0.089: STP1.1 114.1,129.66 113.54,129.1 113.54,128.41 v7(114.04,127.91)
H_PECI: length 57.3
  TOP w0.102: R233.1 R231.1 78.12,155.83 79.39,157.1 v2(82.08,157.1) ; v7(110.39,126.08) CPU.G7
  BOTTOM w0.102: v7(110.39,126.08) 109.93,126.53 109.93,128.21 110.06,128.34 110.57,128.34 111.43,129.2 111.43,132.29 v3(111.78,132.64) 111.78,133.53 107.56,137.75 103.55,137.75 90.49,150.81 90.49,153.41 87.43,156.47 82.72,156.47 v2(82.08,157.1)
H_PRDY_L: length 32.3
  TOP w0.102: R250.2 87.11,139.29 90.26,142.44 98.25,142.44 106.3,134.38 109.93,134.38 112.29,132.03 112.29,131.47 112.65,131.11 CPU.B10
H_PREQ_L: length 33.2
  TOP w0.102: CPU.B9 112.08,131.43 112.08,131.93 109.86,134.16 105.94,134.16 97.97,142.13 90.27,142.13 87.45,139.3 R256.2 R260.2
H_SKTOCC_L: length 326.8
  TOP w0.089: 50.09,74.14 50.45,74.49 PCH1.Y44
  TOP w0.102: CPU.AB35 v7(137.28,112.36) ; v2(53.7,54.74) 53,55.44 53,57.03 52.27,57.75 52.27,57.76 52.11,57.92 52.11,59.18 53.24,60.31 53.24,63.59 52.22,64.61 51.26,64.61 50.7,65.17 50.7,69.97 50.09,70.58 50.09,74.14 ; Q34.G 191.36,92.65 190.67,93.35 R350.2 189.55,94.21 189.33,94.43 Q33.G v2(188.38,94.94)
  BOTTOM w0.102: v2(53.7,54.74) 52.43,53.48 52.43,51.76 53.57,50.62 53.57,49.05 52.75,48.23 52.75,47.69 52.97,47.47 53.6,46.84 53.6,43.24 54.45,42.39 54.45,41.59 55.28,40.76 55.28,39.5 54.45,38.67 54.45,37.79 55.22,37.02 55.22,36.2 55.92,35.5 56.74,35.5 57.38,34.87 86.06,34.87 91.97,28.95 91.97,26.82 96.43,22.36 113.01,22.36 114.02,21.34 114.02,20.2 114.85,19.37 119.24,19.37 120,20.14 127.79,20.14 129.19,21.53 133.68,21.53 136.22,24.07 142.41,24.07 146.09,27.76 156.62,27.76 159.28,30.42 164.22,30.42 165.52,29.13 166.27,29.13 167.04,28.35 167.83,28.35 168.11,28.64 168.11,29.07 168.62,29.57 170.97,29.57 171.3,29.24 171.8,29.24 172.52,29.95 174.63,29.95 177.03,32.35 179.83,32.35 183.87,36.39 183.87,37.72 183.19,38.41 183.19,49.81 187.13,53.75 187.13,54.82 191.17,58.86 191.17,61.47 188.38,64.27 v2(188.38,94.94) 185.48,97.84 v3(181.46,97.84) 174.76,97.84 157.28,115.32 143.27,115.32 141.68,113.73 138.65,113.73 v7(137.28,112.36)
H_SKTOCC_L_R: length 115.7
  TOP w0.102: Q8.G v3(178.23,193.49) 186.21,185.51 186.21,175.9 190.77,171.34 195.1,171.34 198.25,168.19 198.25,97.82 195.36,94.94 Q34.D 192.73,94.94 192.51,95.16 R351.1
H_TCK: length 54
  TOP w0.102: CPU.F11 v7(114.04,126.99) ; R201.1 R202.1 84.37,161.3 83.73,160.66 v2(83.73,159.52)
  BOTTOM w0.102: v7(114.04,126.99) 113.08,127.96 113.08,130.57 113.41,130.9 v3(113.41,131.44) 113.08,131.77 113.08,133.88 108.05,138.92 104.03,138.92 91.65,151.29 91.65,153.9 90.75,154.8 90.75,155.66 88.68,157.74 85.45,157.74 83.73,159.46 v2(83.73,159.52)
H_TDI: length 53.6
  TOP w0.102: v2(83.03,158.18) 81.7,159.52 R214.1 ; v7(114.04,126.08) CPU.G12
  BOTTOM w0.102: v7(114.04,126.08) 112.78,127.35 112.78,133.69 107.9,138.56 103.88,138.56 91.3,151.15 91.3,153.75 90.4,154.65 90.4,155.52 88.53,157.38 84.95,157.38 v3(83.92,158.41) 83.26,158.41 v2(83.03,158.18)
H_TDO: length 52.1
  TOP w0.102: R204.1 86.43,161.8 R210.2 87.61,160.6 v2(87.86,160.34) ; v7(114.96,126.08) CPU.H13
  BOTTOM w0.102: v7(114.96,126.08) 114.96,126.31 115.39,126.74 115.39,130.8 113.87,132.33 113.87,134.1 108.34,139.63 104.32,139.63 92.37,151.59 92.37,154.19 91.47,155.09 91.47,155.96 88.94,158.48 88.27,158.48 v3(87.86,158.9) v2(87.86,160.34)
H_THERMTRIP_L: length 113.4
  TOP w0.102: R313.1 R314.2 54.75,111.8 v2(59.04,116.08) ; CPU.D11 113.21,128.9 111.6,128.9 111.22,129.28 111.22,132.31 109.61,133.93 105.59,133.93 97.87,141.65 90.37,141.65 88.09,139.37 88.09,136.85 87.73,136.49 86.21,136.49 85.43,137.27 85.43,143.44 79.81,149.06 79.39,149.48 v2(79.39,150.88)
  BOTTOM w0.102: v2(59.04,116.08) 60.54,116.08 61.44,116.99 61.44,142.26 66.29,147.11 68.66,147.11 72.18,150.63 77.2,150.63 v3(77.55,150.97) 79.3,150.97 v2(79.39,150.88)
H_TMS: length 50.3
  TOP w0.102: R205.1 87.67,161.97 v2(89.45,161.97) ; v7(115.87,127.91) CPU.F13
  BOTTOM w0.102: v2(89.45,161.97) v3(89.45,159.73) 89.45,158.48 91.82,156.11 91.82,155.24 92.72,154.34 92.72,151.74 104.47,139.98 108.49,139.98 114.22,134.25 114.22,132.5 116.37,130.36 116.37,128.4 v7(115.87,127.91)
H_TRST_L: length 52.5
  TOP w0.102: v7(114.96,126.99) CPU.F12 ; v2(84.56,159.49) 84.56,160.47 85.45,161.36 R203.2
  BOTTOM w0.102: v2(84.56,159.49) 85.69,158.36 v3(86.06,158.36) 86.32,158.1 88.83,158.1 91.11,155.81 91.11,154.94 92.01,154.04 92.01,151.44 104.18,139.27 108.19,139.27 113.49,133.98 113.49,132.23 114.96,130.75 v7(114.96,126.99)
H_VIDALERT_L: length 49.5
  TOP w0.102: R266.1 v2(163.42,135.51) R267.2 ; R165.2 v2(166.09,172.54) R147.2
  BOTTOM w0.102: v2(163.42,135.51) 164.16,136.25 164.16,136.96 154.76,146.36 154.76,155.69 162.64,163.56 162.64,169.52 164.78,171.67 165.23,171.67 v2(166.09,172.54)
H_VIDSCK: length 50.5
  TOP w0.102: R148.2 v2(167.23,172.61) R166.2 ; R270.1 v2(163.42,134.44)
  BOTTOM w0.102: v2(163.42,134.44) 164.67,135.68 164.67,137.57 155.25,147 155.25,155.42 163.12,163.29 163.12,169.32 164.98,171.19 165.81,171.19 v2(167.23,172.61)
H_VIDSOUT: length 47.5
  TOP w0.102: R261.1 v2(163.42,136.59) R262.2 ; R146.2 v2(164.95,172.54) R164.2
  BOTTOM w0.102: v2(163.42,136.59) 154.28,145.74 154.28,155.89 162.15,163.76 162.15,169.74 v2(164.95,172.54)
HDA_BCLK_R: length 9.7
  TOP w0.089: PCH1.BA9 39.57,96.27 39.01,96.82 37.33,96.82 32.61,101.54 R336.2
HDA_BITCLK: length 86.9
  TOP w0.089: R336.1 32.54,102.84 32.02,103.36
  TOP w0.102: CODEC.6 18.46,178.63 18.87,178.22 18.87,177.23 C114.1 19.37,176.95 19.53,177.11 v2(19.53,177.81) ; 32.02,103.36 31.6,103.78 31.6,106.34 v2(31.29,106.65)
  BOTTOM w0.102: v2(19.53,177.81) 19.66,177.81 23.28,174.19 23.28,170.9 25.86,168.32 25.86,148.57 24.04,146.75 24.04,113.9 v3(29.34,108.6) v2(31.29,106.65)
HDA_RST_L: length 84.5
  TOP w0.102: v2(22.43,173.6) 22.43,174.08 23.53,175.19 R135.2 23.3,176.36 23.1,176.36 C113.1 22.45,178.19 20.96,179.68 CODEC.11 ; v2(30.72,106.06) 31.12,105.67 31.12,103.58 31.53,103.16 R335.1
  BOTTOM w0.102: v2(22.43,173.6) 22.8,173.23 22.8,170.64 25.38,168.06 25.38,148.85 23.51,146.98 23.51,113.26 v3(27.66,109.11) 27.67,109.11 v2(30.72,106.06)
HDA_RST_L_R: length 9.1
  TOP w0.089: PCH1.BD8 37.31,96.57 32.02,101.86
  TOP w0.102: R335.2 31.99,101.89 32.02,101.86
HDA_SDIN0: length 92.1
  TOP w0.089: PCH1.BE7 37.35,97.07 33.19,101.24 33.19,102.93 32.08,104.03 32.08,105.69
  TOP w0.102: R137.1 20.23,176.35 20.74,176.85 20.74,177.93 v2(20.8,178) ; v2(31.74,107.27) 32.08,106.93 32.08,105.69
  BOTTOM w0.102: v2(20.8,178) 20.8,177.35 23.81,174.34 23.81,171.05 26.34,168.52 26.34,148.34 24.55,146.55 24.55,114.46 v3(26.26,112.74) v2(31.74,107.27)
HDA_SDO_MED: length 55.5
  TOP w0.102: R615.2 29.38,101.61 v2(28.8,102.18) ; v2(17.37,65.32) 17.76,64.94 24.05,64.94 25.45,66.34 26.68,66.34 27.6,67.25 RJ3.2
  BOTTOM w0.102: v2(17.37,65.32) 17.63,65.58 17.63,77.34 21.64,81.35 21.64,97.3 v3(25.58,101.24) 26.52,102.18 v2(28.8,102.18)
HDA_SDO_R: length 15.4
  TOP w0.089: PCH1.BB7 39.91,96.62 40.08,96.62 v6(40.14,96.56)
  TOP w0.102: R333.2 29.88,102.34 v2(29.88,102.18) 30.39,101.67 R615.1
  BOTTOM w0.089: v6(40.14,96.56) 40.02,96.44 v3(37.36,96.44) 36.64,97.16 35.22,97.16 31.26,101.12
  BOTTOM w0.102: v2(29.88,102.18) 30.2,102.18 31.26,101.12
HDA_SDO_R1: length 10.2
  TOP w0.102: RJ3.1 28.17,67.89 28.17,65.75 28.65,65.27 32.77,65.27 33.9,64.14 ME_DISABLE.2
HDA_SDO_R_P1: length 4.4
  TOP w0.102: ME_DISABLE.3 36.69,64.14 34.66,66.17 R430.1
HDA_SDOUT: length 83.9
  TOP w0.102: R333.1 29.47,104.94 v2(29.55,105.02) ; v2(17.96,179.08) CODEC.5
  BOTTOM w0.102: v2(17.96,179.08) 17.96,178.17 19.79,176.35 19.79,174.74 22.31,172.22 22.31,170.46 24.92,167.86 24.92,149.05 23.05,147.19 23.05,111.52 v3(24.04,110.53) v2(29.55,105.02)
HDA_SYNC: length 81.9
  TOP w0.102: CODEC.10 20.46,179.68 21.88,178.25 21.88,175.09 21.08,174.29 v2(21.08,174.24) ; v2(30.1,105.63) 30.65,105.09 R334.1
  BOTTOM w0.102: v2(21.08,174.24) 22.57,172.75 22.57,170.54 25.15,167.96 25.15,148.95 23.28,147.08 23.28,112.43 v3(25.83,109.87) 25.86,109.87 v2(30.1,105.63)
HDA_SYNC_R: length 12.3
  TOP w0.089: PCH1.BD9 38.27,96.09 38.1,96.26 37.35,96.26 32.88,100.73 32.37,101.24 32.02,101.24
  TOP w0.102: 32.02,101.24 31.44,101.24 30.96,101.71 30.96,103.13 30.65,103.45 R334.2
HDD_LED_N: length 9.1
  TOP w0.102: Q66.C 103.16,9.34 101.83,8.01 101.83,6.97 102.25,6.55 102.25,4.17 F_PANEL.3
HDD_LED_P: length 2.4
  TOP w0.508: F_PANEL.1 97.77,3.31 R610.2
HDMI_CLK_N3: length 7.5
  TOP w0.102: C56.2 134.5,190.35 134.66,190.51 135.1,190.51 135.29,190.7 135.29,191.3 135.45,191.45 135.57,191.45 135.75,191.27 RN4.7 136.52,191.27 136.61,191.17 136.61,190.77 136.88,190.51 138.15,190.51 138.41,190.76 138.41,190.99 138.64,191.23 138.82,191.23 138.91,191.13 138.91,190.94 139.08,190.78 CHOKE4.4
HDMI_CLK_N3_R: length 19
  TOP w0.102: RN5.8 141.98,190.87 142.29,191.18 142.6,191.18 142.72,191.31 142.88,191.31 143.09,191.09 U5.5 U5.6 144.8,191.09 144.96,191.25 145.92,191.25 149.6,194.93 152.91,194.93 154.55,196.57 154.55,197.87 154.73,198.05 HDMI.12
HDMI_CLK_P3: length 7.5
  TOP w0.102: C45.2 134.5,190.89 134.68,190.71 135.02,190.71 135.09,190.78 135.09,191.38 135.37,191.66 135.57,191.66 135.75,191.84 RN4.5 136.56,191.84 136.82,191.59 136.82,190.86 136.97,190.71 138.07,190.71 138.2,190.84 138.2,191.07 138.56,191.43 138.88,191.43 139.08,191.63 CHOKE4.1
HDMI_CLK_P3_R: length 19
  TOP w0.102: RN5.6 141.98,191.69 142.29,191.38 142.51,191.38 142.64,191.51 142.95,191.51 143.04,191.59 U5.4 U5.7 144.8,191.59 144.93,191.46 145.83,191.46 149.51,195.13 152.83,195.13 154.35,196.65 154.35,197.81 154.28,197.87 153.9,197.87 153.73,198.04 HDMI.10
HDMI_CTRLCLK: length 161.5
  TOP w0.089: PCH1.BE5 37.95,98.13 37.82,98.27 37.22,98.27 34.07,101.42 34.07,105.35 33.88,105.54 33.88,105.69
  TOP w0.102: v2(52.17,122.69) 51.98,122.88 46.14,122.88 43.28,120.02 42.08,120.02 35.47,113.42 35.47,112.49 33.88,110.9 33.88,105.69 ; v2(87.92,168.03) 88.43,168.53 92.38,168.53 104.32,180.47 128.56,180.47 130.15,182.06 130.15,183.14 130.63,183.62 R101.2 130.91,185.11 131.42,185.62 133.77,185.62 134.34,185.04 134.34,184.66
  BOTTOM w0.102: v2(87.92,168.03) 86.97,168.03 83,164.06 81.86,164.06 78.65,160.85 74.94,160.85 70.88,156.79 67.26,156.79 51.26,140.79 51.26,127.35 v3(51.87,126.74) 52.83,125.77 52.83,123.35 v2(52.17,122.69)
HDMI_CTRLDATA: length 158.5
  TOP w0.089: 33.63,105.69 33.63,105.35 33.76,105.23 33.76,101.29 37.41,97.63 PCH1.BE6
  TOP w0.102: v2(51.54,123.39) 46.29,123.39 43.18,120.27 41.97,120.27 35.22,113.52 35.22,112.59 33.63,111 33.63,105.69 ; v2(88.75,168.03) 89,168.28 92.46,168.28 104.14,179.96 129.07,179.96 129.61,180.5 R109.2 130.91,180.13 131.2,179.84 134.02,179.84 134.34,180.16 134.34,180.73
  BOTTOM w0.102: v2(88.75,168.03) 88.14,168.64 87.26,168.64 82.93,164.31 81.76,164.31 78.52,161.08 74.84,161.08 70.78,157.02 67.16,157.02 51.03,140.88 51.03,126.18 51.89,125.32 v3(51.89,124.66) 51.54,124.3 v2(51.54,123.39)
HDMI_HPD: length 164
  TOP w0.089: PCH1.AV4 41.46,97.87 v6(41.51,97.82)
  TOP w0.102: R103.2 139.33,181.84 Q12.S 137.07,179.58 104.14,179.58 92.58,168.03 89.89,168.03 88.75,166.88 87.73,166.88 v2(87.41,167.2) ; v2(35.98,113.04) 35.98,113.6 42.17,119.79 43.38,119.79 45.92,122.33 v2(51.47,122.33)
  BOTTOM w0.102: v2(51.47,122.33) 51.63,122.18 52.36,122.18 53.06,122.88 53.06,126.82 51.49,128.39 51.49,140.69 67.35,156.56 70.97,156.56 75.03,160.62 78.75,160.62 81.92,163.8 83.07,163.8 86.47,167.2 v2(87.41,167.2) ; v6(41.51,97.82) 41.68,97.99 v3(41.68,99.84) 41.17,100.35 41.17,106.65 40.28,107.54 40.28,109.16 36.41,113.04 v2(35.98,113.04)
HDMI_HPD_CNN: length 32.1
  TOP w0.102: HDMI.19 158.23,197.82 153.77,193.36 151.04,193.36 141.71,184.03 140.31,184.03 140.06,184.28 U9.1 139.59,185.64 v1(139.04,185.08) 138.34,184.38 C75.1 R83.1 137.07,183.14 Q12.D
