# Allegro board ECS H11H4-AI-V1.0-OK.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on TOP (solid shape): 87.71,129.2 87.71,128.03 86.61,126.94 80.54,126.94 80.29,127.2 80.29,129.18 80.44,129.33 87.58,129.33
GND on TOP (solid shape): 105.51,24.2 105.51,19.82 105.26,19.56 104.5,19.56 101.58,22.48 101.58,24.33 101.77,24.52 105.19,24.52
GND on TOP (solid shape): 137.71,208.92 137.71,201.87 137.2,201.36 131.04,201.36 129.01,203.4 129.01,208.86 129.58,209.43 137.2,209.43
GND on TOP (solid shape): 190.48,139.58 190.48,139.13 190.22,138.88 187.11,138.88 186.98,139.01 186.98,139.39 187.24,139.64 190.41,139.64
GND on TOP (solid shape): 195.56,162.88 195.56,160.09 195.17,159.71 188.19,159.71 187.43,160.47 187.43,163.01 187.68,163.26 195.17,163.26
GND on TOP (solid shape): 117.64,162.95 117.64,159.64 116.37,159.64 116.05,159.96 115.04,159.96 114.78,160.22 114.78,162.69 115.1,163.01 117.58,163.01
GND on TOP (solid shape): 131.06,119.32 131.06,108.22 130.86,108.02 128.17,108.02 127.97,108.22 127.97,119.22 128.25,119.5 130.89,119.5
GND on TOP (solid shape): 184.32,154.76 184.32,152.41 184.19,152.28 180.89,152.28 180.89,155.01 181.08,155.2 183.87,155.2
GND on TOP (solid shape): 43.79,21.91 43.79,21.41 42.01,19.63 38.84,19.63 38.33,20.14 38.33,21.91 38.58,22.17 43.54,22.17
GND on TOP (solid shape): 45.76,163.58 45.76,161.68 45.5,161.42 44.87,161.42 44.36,161.93 44.36,164.09 43.66,164.79 43.66,165.17 43.79,165.3 44.04,165.3
GND on TOP (solid shape): 55.16,14.86 55.16,13.09 54.59,12.52 53.19,12.52 51.92,13.79 49.25,13.79 48.93,14.1 48.93,14.61 49.51,15.18 54.84,15.18
GND on TOP (solid shape): 62.74,108.63 62.74,107.54 61.82,106.62 61.82,106.06 61.24,105.48 60.78,105.48 60.53,105.73 60.53,108.73 60.76,108.97 62.4,108.97
GND on TOP (solid shape): 110.02,71.06 110.02,65.47 109.77,65.22 109.07,65.22 108.88,65.41 108.88,71 109.2,71.32 109.77,71.32
GND on TOP (solid shape): 111.48,160.79 111.48,159.84 110.97,159.33 105.07,159.33 104.69,159.71 104.69,160.53 104.81,160.66 105.83,160.66 106.27,161.11 111.16,161.11
GND on TOP (solid shape): 114.34,34.74 114.34,32.26 114.08,32.01 112.88,32.01 112.56,32.33 112.56,32.58 113.32,33.34 113.32,34.74 113.58,34.99 114.08,34.99
GND on TOP (solid shape): 126.66,205.24 126.66,203.71 126.28,203.33 125.58,203.33 125.2,203.71 125.2,204.6 124.05,205.75 124.05,206.57 124.31,206.83 125.07,206.83
GND on TOP (solid shape): 31.34,38.93 31.34,35.95 30.84,35.44 30.33,35.44 30.01,35.76 30.01,36.58 30.2,36.77 30.2,38.93 30.46,39.19 31.09,39.19
GND on TOP (solid shape): 55.92,35.12 55.92,34.23 56.17,33.98 56.62,33.98 56.74,33.85 56.74,33.47 56.68,33.41 54.71,33.41 54.52,33.6 54.52,35.63 54.71,35.82 55.22,35.82
GND on TOP (solid shape): 68.43,74.29 68.43,71.19 67.48,70.24 66.71,70.24 66.4,70.55 66.4,74.26 66.68,74.54 68.17,74.54
GND on TOP (solid shape): 75.74,134.23 75.74,132.17 75.67,132.1 74.35,132.1 74.13,132.31 72.78,132.31 72.47,132.63 72.47,133.04 73.33,133.9 73.33,134.13 73.51,134.31 75.67,134.31
GND on TOP (solid shape): 100.32,165.49 101.15,165.49 101.17,165.47 101.17,163.31 100.23,162.38 97.7,162.38 97.51,162.57 97.51,164.85 98.16,165.5 100.32,165.5
GND on TOP (solid shape): 113.77,153.8 113.77,149.36 113.58,149.17 112.5,149.17 112.31,149.36 112.31,153.87 112.43,153.99 113.58,153.99
GND on TOP (solid shape): 115.93,155.01 117.51,155.01 117.64,154.88 117.64,151.14 115.1,151.14 114.85,151.39 114.85,155.33 115.1,155.58 115.35,155.58
GND on TOP (solid shape): 127.74,21.91 127.74,20.52 127.29,20.07 124.56,20.07 123.74,20.9 122.59,20.9 122.47,21.02 122.47,21.47 122.66,21.66 124.05,21.66 124.5,22.1 127.55,22.1
GND on TOP (solid shape): 174.79,101.61 176.31,100.08 176.31,99.83 176.12,99.64 173.58,99.64 171.36,101.86 171.36,102.94 171.49,103.07 174.79,103.07
GND on TOP (solid shape): 35.81,72.28 35.81,69.72 35.2,69.11 33.71,69.11 33.54,69.27 33.54,70.39 34.49,71.34 34.49,72.33 34.51,72.34 34.51,72.51 34.77,72.78 35.32,72.78
GND on TOP (solid shape): 78.36,137.31 78.36,137.05 77.75,136.44 77.75,135.35 77.72,135.35 77.7,135.32 77.14,135.32 77.14,136.14 77.09,136.19 77.09,136.8 77.78,137.48 78.18,137.48
GND on TOP (solid shape): 99.92,208.98 99.92,200.03 99.86,199.97 97.83,199.97 95.92,201.87 87.61,201.87 85.57,199.84 83.67,199.84 83.29,200.22 83.29,208.73 83.92,209.37 99.54,209.37
GND on TOP (solid shape): 176.7,136.47 176.7,135.77 176.19,135.26 176.19,133.93 176.06,133.8 172.38,133.8 172.38,136.53 172.57,136.72 176.44,136.72
GND on TOP (solid shape): 183.52,136.12 184.41,136.12 184.7,135.83 184.7,134.31 184.19,133.8 180.89,133.8 180.89,136.53 181.08,136.72 182.92,136.72
GND on TOP (solid shape): 9.25,92.02 9.25,89.22 8.87,88.84 5.63,88.84 5.5,88.97 5.5,89.79 6.33,90.62 6.33,91.13 6.58,91.38 7.21,91.38 8.23,92.4 8.87,92.4
GND on TOP (solid shape): 41.31,116.91 41.31,110.11 41.12,109.92 40.04,109.92 39.92,110.05 39.92,112.2 39.75,112.36 39.75,114.15 39.41,114.5 38.9,114.5 38.77,114.62 38.77,115 40.81,117.04 41.19,117.04
GND on TOP (solid shape): 45.65,159.03 45.65,157.32 45.42,157.08 40.09,157.08 40.01,157.17 40.01,158.11 40.06,158.16 40.69,158.16 40.86,158.33 40.86,158.91 40.95,159 41.61,159 41.77,159.16 45.52,159.16
GND on TOP (solid shape): 58.14,72.71 58.14,69.98 59.98,68.14 59.98,65.98 58.97,64.97 56.11,64.97 55.86,65.22 55.86,70.36 56.3,70.81 56.3,72.65 56.68,73.03 57.82,73.03
GND on TOP (solid shape): 80.46,121.29 80.46,119.89 78.55,117.99 78.55,117.46 78.23,117.14 77.7,117.14 77.32,117.52 77.32,120.29 77.62,120.59 78.38,120.59 79.25,121.46 80.29,121.46
GND on TOP (solid shape): 131.55,32.33 131.55,29.71 131.53,29.67 131.5,29.66 129.32,29.66 128.25,30.74 128.25,31.5 127.55,32.2 127.55,32.45 127.67,32.58 131.29,32.58
GND on TOP (solid shape): 132.69,156.66 132.69,156.28 132.94,156.03 133.52,156.03 133.64,155.9 133.64,155.58 134.4,154.82 134.4,151.14 132.63,151.14 131.93,151.83 131.93,156.66 132.06,156.79 132.56,156.79
GND on TOP (solid shape): 134.4,162.95 134.4,159.7 134.39,159.66 134.35,159.64 131.8,159.64 131.61,159.84 131.61,162.31 131.8,162.5 132.69,162.5 133.26,163.07 134.28,163.07
GND on TOP (solid shape): 139.04,166.95 139.04,166.59 138.89,166.44 138.2,166.44 138.05,166.29 136.37,166.29 136.07,165.98 135.51,165.98 135.38,166.11 135.38,166.54 135.56,166.72 135.87,166.72 136.25,167.1 138.89,167.1
GND on TOP (solid shape): 183.3,101.77 182.07,100.54 182.07,99.87 181.84,99.64 178.92,99.64 178.73,99.83 178.73,100.08 179.43,100.78 179.43,102.49 180,103.07 183.3,103.07
GND on TOP (solid shape): 190.53,123.01 190.53,122.12 190.17,121.76 189.48,121.76 189.38,121.66 187.5,121.66 187.4,121.76 187.4,122.34 187.5,122.45 189.36,122.45 190.09,123.18 190.35,123.18
GND on TOP (solid shape): 9.88,78.24 9.88,77.09 8.8,76.02 7.63,76.02 7.32,76.33 7.32,76.9 8.03,77.62 8.03,78.3 8.03,78.31 8.03,78.42 8.23,78.62 9.5,78.62
GND on TOP (solid shape): 49.43,177.77 49.43,174.95 49.15,174.67 48.57,174.67 47.56,173.67 47,173.67 46.86,173.81 46.86,174.41 46.99,174.54 46.99,177.84 47.17,178.02 49.17,178.02
GND on TOP (solid shape): 73.53,120.97 73.53,117.44 73.97,117.01 73.97,116.38 73.79,116.2 72.39,116.2 71.91,116.68 71.91,117.21 72.21,117.52 72.21,120.92 72.44,121.15 73.36,121.15
GND on TOP (solid shape): 118.8,166.97 118.8,166.41 118.67,166.29 116.94,166.29 116.71,166.06 116.71,165.85 116.48,165.63 116.03,165.63 115.82,165.83 115.82,166.77 116,166.95 116.64,166.95 116.79,167.1 118.67,167.1
GND on TOP (solid shape): 176.95,155.01 176.95,154.5 176.19,153.74 176.19,152.41 176.06,152.28 172.38,152.28 172.38,155.01 172.57,155.2 176.76,155.2
GND on TOP (solid shape): 5.13,86.33 5.13,86.25 5.13,84.52 5.13,84.35 5.36,84.12 8.51,84.12 8.59,84.04 8.59,81.48 8.51,81.4 4.57,81.4 4.42,81.55 4.42,86.35 4.5,86.43 5.03,86.43
GND on TOP (solid shape): 49.19,9.21 50.27,9.21 50.46,9.02 50.46,5.59 50.14,5.28 49.44,5.28 48.93,5.78 47.79,5.78 47.54,6.04 47.54,9.54 47.55,9.58 47.59,9.59 48.81,9.59
GND on TOP (solid shape): 85.64,190.82 85.64,190.44 85.51,190.32 85.51,190.31 85.38,190.18 85.38,187.93 85.39,187.91 85.39,186.58 85.13,186.31 84.24,186.31 84.05,186.51 84.05,190.89 84.18,191.01 85.45,191.01
GND on TOP (solid shape): 115.48,209.05 115.48,207.65 116.31,206.83 120.63,206.83 120.94,206.51 120.94,205.75 120.5,205.3 115.1,205.3 114.53,204.73 114.53,204.09 113.89,203.46 101.26,203.46 100.81,203.9 100.81,208.98 101.26,209.43 115.1,209.43
GND on TOP (solid shape): 119.3,118.99 119.3,108.53 118.92,108.15 116.48,108.15 116.18,108.45 116.18,110.43 115.95,110.66 115.95,118.13 116.13,118.31 117.55,118.31 118.54,119.3 119,119.3
GND on TOP (solid shape): 132.68,74.3 132.71,74.29 132.73,74.25 132.73,69.15 132.1,68.52 131.64,68.52 131.42,68.73 131.42,68.8 131.42,68.8 131.42,69.73 131.55,69.86 131.55,74.17 131.67,74.3
GND on TOP (solid shape): 46.4,33.21 46.4,31.04 46.4,30.24 46.36,30.19 43.16,30.19 42.86,30.49 42.86,31.57 42.6,31.84 42.59,31.85 42.58,31.87 42.58,32.96 42.77,33.15 43.92,33.15 44.93,34.17 45.44,34.17
GND on TOP (solid shape): 59.3,78.89 59.7,78.89 60.41,78.17 60.41,77.56 60.24,77.39 60,77.39 59.12,78.28 59.1,78.3 59.1,78.32 59.1,78.52 58.96,78.66 58.95,78.68 58.95,78.69 58.95,78.91 59.1,79.05 59.14,79.05
GND on TOP (solid shape): 94.91,180.03 94.91,176.6 94.65,176.35 94.65,175.33 94.21,174.88 90.34,174.88 90.08,175.14 90.08,176.73 90.18,176.83 92.09,176.83 92.49,177.23 92.49,180.03 92.62,180.16 94.78,180.16
GND on TOP (solid shape): 106.34,167.14 106.34,164.61 106.21,164.48 105.36,164.48 104.55,164.48 104.52,164.51 104.52,164.99 104.45,165.07 103.2,165.07 103.18,165.09 103.18,166.24 103.23,166.29 104.43,166.29 104.69,166.54 104.69,167.26 104.81,167.39 106.08,167.39
GND on TOP (solid shape): 199.43,207.33 199.43,191.78 198.98,191.33 194.98,191.33 194.67,191.65 194.67,204.35 194.09,204.92 184.19,204.92 183.36,204.09 182.09,204.09 181.01,205.17 177.9,205.17 177.01,206.06 177.01,208.92 177.52,209.43 197.33,209.43
GND on TOP (solid shape): 31.83,159.86 32.77,159.86 33,160.09 33,160.39 33.2,160.6 33.66,160.6 33.76,160.5 33.76,159.86 34.16,159.45 34.16,158.92 33.93,158.69 32.74,158.69 31.76,157.71 31.19,157.71 30.2,158.69 22.01,158.69 21.76,158.95 21.76,159.94 22.64,160.83 30.86,160.83
GND on TOP (solid shape): 71.79,113.42 71.79,110.81 71.54,110.56 68.81,110.56 68.43,110.94 68.43,112.02 68.49,112.08 68.81,112.08 69.29,111.6 69.36,111.6 69.57,111.38 70.02,111.38 70.27,111.64 70.27,111.96 69.76,112.46 69.24,112.46 68.42,113.29 68.42,113.62 68.59,113.8 71.41,113.8
GND on TOP (solid shape): 90.46,18.23 90.46,15.37 90.02,14.93 89.32,14.93 89.07,14.67 89.07,12.58 89.38,12.26 93.76,12.26 94.21,11.82 94.21,5.34 93.76,4.9 88.62,4.9 88.05,5.47 88.05,12.9 87.03,13.91 87.03,17.15 88.43,18.55 90.15,18.55
GND on TOP (solid shape): 103.99,34.68 103.99,33.34 103.54,32.9 102.91,32.9 102.72,32.71 102.72,28.07 102.21,27.56 96.11,27.56 95.73,27.95 95.73,28.77 95.92,28.96 96.5,28.96 96.75,28.71 99.86,28.71 99.99,28.83 99.99,32.84 99.73,33.09 94.34,33.09 93.83,33.6 93.83,34.74 94.08,34.99 103.67,34.99
GND on TOP (solid shape): 189.41,100.63 189.41,99.84 189.48,99.76 190.12,99.76 190.45,100.09 190.45,100.58 190.53,100.65 191.12,100.65 191.3,100.48 191.3,99.13 191.17,99 188.32,99 188.19,99.13 188.19,99.64 188.32,99.76 189.03,99.76 189.1,99.84 189.1,100.63 189.13,100.65 189.38,100.65
GND on TOP (solid shape): 38.62,79.45 38.62,79.11 38.59,79.08 38.59,78.57 38.54,78.52 38.54,78.48 38.52,78.46 38.52,78.24 37.65,77.37 36.97,77.37 36.84,77.49 36.84,77.83 37,77.99 37.02,77.99 37.94,78.91 37.95,78.92 37.97,78.92 38.15,78.92 38.25,79.02 38.25,79.39 38.37,79.51 38.56,79.51
GND on TOP (solid shape): 169.84,209.05 169.84,207.14 169.33,206.63 167.11,206.63 165.01,204.54 157.84,204.54 157.39,204.09 157.39,201.94 157.14,201.68 148.76,201.68 148.44,201.36 148.44,199.52 147.74,198.82 144.06,198.82 143.23,199.65 143.23,202.63 142.47,203.4 138.79,203.4 138.28,203.9 138.28,208.92 138.79,209.43 169.46,209.43
GND on TOP (solid shape): 24.87,14.55 24.87,13.02 25.12,12.77 25.63,12.77 26.01,12.39 26.01,12.13 25.76,11.88 25.12,11.88 24.87,11.63 24.87,9.66 24.74,9.53 24.23,9.53 24.17,9.59 24.17,10.42 24.07,10.52 24.07,12.12 24.04,12.14 24.04,12.64 23.79,12.9 20.93,12.9 20.87,12.96 20.87,15.25 20.93,15.31 24.11,15.31
GND on TOP (solid shape): 47.14,28.19 47.14,26.94 47.28,26.8 47.79,26.8 49.45,25.14 49.45,24.73 49.61,24.58 50.14,24.58 50.27,24.45 50.27,23.95 48.81,22.48 47.21,22.48 46.81,22.88 46.81,24.86 46.58,25.09 46.33,25.09 45.39,26.03 45.39,26.82 45.44,26.87 45.85,26.87 45.95,26.97 45.95,28.14 46.03,28.21 47.12,28.21
GND on TOP (solid shape): 81.5,136.45 81.65,136.45 82.46,135.64 82.46,134.5 82.08,134.12 81.32,134.12 81.13,133.93 81.13,133.51 81.04,133.42 80.15,133.42 80.05,133.32 79.12,133.32 79.12,133.72 78.94,133.9 77.83,133.9 77.72,134 77.72,135.04 77.78,135.1 78.92,135.1 80.29,136.47 81.48,136.47
GND on TOP (solid shape): 132.53,27.85 133.36,27.85 133.36,27.86 134.24,27.86 134.39,27.7 134.39,27.45 134.21,27.27 133.96,27.27 133.58,27.65 132.54,27.65 132.46,27.57 132.42,27.57 132.42,27.54 132.28,27.4 132.28,26.54 132.42,26.4 132.42,26.32 132.5,26.32 132.51,26.31 133.12,26.31 134.02,25.41 134.02,24.26 133.64,23.88 132.69,23.88 132.37,24.2 132.37,25.23 132.16,25.44 132.16,26.38 132.06,26.49 131.62,26.49 131.55,26.41 131.55,25.44 131.52,25.42 131.37,25.42 131.34,25.44 131.34,26.26 131.34,26.31 131.17,26.49 131.17,27.55 131.18,27.59 131.22,27.6 132.21,27.6 132.32,27.72 132.38,27.72 132.38,27.77 132.46,27.86 132.53,27.86
GND on TOP (solid shape): 30.28,92.02 31.22,92.02 31.85,91.38 31.22,90.75 30.28,90.75 30.28,87.47 27.08,87.47 27.08,90.75 26.14,90.75 25.5,91.38 26.14,92.02 27.08,92.02 27.08,96.46 30.28,96.46
GND on TOP (solid shape): 39.96,100.11 39.96,100.04 39.96,100.04 39.96,99.65 39.9,99.59 39.89,99.58 39.53,99.58 39.52,99.58 39.32,99.56 39.19,99.41 39.17,99.38 39.13,99.37 39.03,99.38 38.92,99.36 38.91,99.36 38.5,99.36 38.25,99.61 38.25,99.66 38.26,99.7 38.3,99.71 38.52,100.19 38.04,99.97 38.03,99.93 37.99,99.92 37.94,99.92 37.87,99.99 37.87,100.81 38.05,100.98 39.09,100.98
GND on TOP (solid shape): 125.37,119.02 125.37,118.45 125.31,118.23 125.37,118.02 125.37,117.02 125.32,116.82 125.37,116.62 125.37,114.73 125.3,114.5 125.37,114.26 125.37,113.08 125.3,112.85 125.37,112.61 125.37,111.69 125.37,111.68 125.34,111.51 125.37,111.34 125.37,111.33 125.37,110.74 125.37,110.73 125.34,110.56 125.37,110.39 125.37,110.38 125.37,109.53 125.37,109.52 125.34,109.35 125.37,109.18 125.37,109.17 125.37,108.45 125.35,108.36 125.34,108.28 125.34,108.26 125.17,108.1 123.93,108.1 123.65,108.37 123.65,119.17 123.75,119.27 125.12,119.27
GND on TOP (solid shape): 111.85,123.11 111.88,123.1 112.04,122.97 112.23,122.93 112.3,122.9 112.33,122.84 112.67,122.54 113.01,122.84 113.05,122.9 113.11,122.93 113.28,122.97 113.43,123.1 113.45,123.11 113.69,123.11 113.82,122.98 113.82,122.85 113.6,122.64 113.6,122.35 113.59,122.32 113.56,122.3 113.32,122.18 113.25,121.93 113.25,121.92 113.24,121.89 113.06,121.71 112.61,121.71 112.45,121.87 112.45,122.18 112.37,122.25 112.37,122.27 111.99,122.65 111.63,122.65 111.51,122.78 111.51,122.98 111.51,123 111.52,123.02 111.56,123.05 111.59,123.09 111.6,123.1 111.63,123.11
GND on TOP (solid shape): 41.28,87.73 41.35,87.69 41.53,87.59 41.73,87.59 41.83,87.57 41.86,87.47 41.85,87.44 41.85,87.4 41.82,87.33 41.75,87.3 41.45,87.14 41.39,86.8 41.39,86.77 41.38,86.75 41.32,86.69 41.32,86.49 41.32,86.47 41.3,86.45 41.21,86.32 41.2,86.15 41.17,86.06 41.07,86.03 40.86,86.03 40.69,85.93 40.62,85.9 40.55,85.92 40.44,85.97 40.32,85.99 40.31,85.99 40.28,86 40.24,86.1 40.23,86.13 40.25,86.16 40.46,86.37 40.46,86.57 40.46,86.59 40.48,86.61 40.52,86.64 40.56,86.69 40.64,86.85 40.63,87.02 40.64,87.09 40.7,87.14 40.85,87.28 40.88,87.48 40.88,87.56 40.94,87.6 40.97,87.61 41.1,87.63 41.21,87.7
GND on TOP (solid shape): outline of 259 points within 31.67,40.4 40.67,49.4
GND on TOP (solid shape): outline of 259 points within 189.15,172.48 198.15,181.48
GND on TOP (solid shape): outline of 259 points within 189.15,40.4 198.15,49.4
GND on TOP (solid shape): outline of 8845 points within 38.63,78.75 60.45,101.67
GND on BOTTOM (solid shape): 46.39,32.58 46.39,31.44 46.14,31.18 42.9,31.18 42.65,31.44 42.65,32.52 42.9,32.77 46.2,32.77
GND on BOTTOM (solid shape): 50.94,90.57 50.94,89.43 50.81,89.3 49.09,89.3 48.96,89.43 48.96,90.62 48.97,90.64 50.88,90.64
GND on BOTTOM (solid shape): 116.24,154.06 116.24,151.01 115.99,150.75 114.97,150.75 114.66,151.07 114.66,154.06 114.91,154.31 115.99,154.31
GND on BOTTOM (solid shape): 117.7,162.76 117.7,159.96 117.45,159.71 114.91,159.71 114.66,159.96 114.66,162.5 115.16,163.01 117.45,163.01
GND on BOTTOM (solid shape): 133.01,162.44 133.01,159.77 132.82,159.58 131.8,159.58 131.55,159.84 131.55,162.38 131.8,162.63 132.82,162.63
GND on BOTTOM (solid shape): 133.01,156.34 133.01,151.71 132.88,151.58 132.12,151.58 131.93,151.77 131.93,156.72 131.99,156.79 132.56,156.79
GND on BOTTOM (solid shape): 137.71,208.92 137.71,201.87 137.2,201.36 131.04,201.36 129.58,202.82 129.58,208.86 130.15,209.43 137.2,209.43
GND on BOTTOM (solid shape): 172.44,183.46 172.44,179.01 172.06,178.63 167.36,178.63 167.11,178.89 167.11,183.46 167.36,183.71 172.19,183.71
GND on BOTTOM (solid shape): 176.31,154.95 176.31,152.6 175.93,152.22 173.27,152.22 173.08,152.41 173.08,155.01 173.27,155.2 176.06,155.2
GND on BOTTOM (solid shape): 184.06,155.01 184.06,154.06 183.81,153.8 181.14,153.8 180.95,153.99 180.95,155.01 181.2,155.26 183.81,155.26
GND on BOTTOM (solid shape): 195.56,163.07 195.56,159.9 195.36,159.71 188.19,159.71 187.43,160.47 187.43,163.01 187.68,163.26 195.36,163.26
GND on BOTTOM (solid shape): 58.33,9.86 58.33,6.36 58.06,6.09 56.85,6.09 56.49,6.44 56.49,9.85 56.69,10.05 58.14,10.05
GND on BOTTOM (solid shape): 118.64,166.64 118.64,166.46 118.44,166.26 118.44,164.79 118.24,164.58 116.15,164.58 116,164.74 116,166.19 116.76,166.95 118.34,166.95
GND on BOTTOM (solid shape): 130.73,118.7 130.73,109.03 129.72,108.01 128.54,108.01 127.93,108.63 127.93,117.73 129.4,119.21 130.23,119.21
GND on BOTTOM (solid shape): 47.99,92.16 47.99,91.34 47.69,91.03 46.8,91.03 46.65,90.88 45.96,90.88 45.81,91.03 45.81,91.93 46.24,92.37 47.79,92.37
GND on BOTTOM (solid shape): 190.5,123.97 190.5,121.94 190.2,121.63 187.86,121.63 187.66,121.84 187.66,122.32 188.54,123.21 188.54,124.02 188.7,124.17 190.3,124.17
GND on BOTTOM (solid shape): 139.04,167.05 139.04,166.67 138.86,166.49 138.13,166.49 137.82,166.19 137.82,164.41 137.59,164.18 136.14,164.18 135.69,164.64 135.69,167 135.97,167.28 138.81,167.28
GND on BOTTOM (solid shape): 175.79,100.53 177.19,100.53 178.21,101.54 181.89,101.54 182.07,101.36 182.07,99.84 181.84,99.61 173.84,99.61 172.26,101.19 172.26,101.39 172.62,101.75 174.57,101.75
GND on BOTTOM (solid shape): 189.56,141.04 189.56,139.08 189.46,138.98 187.12,138.98 187,139.11 187,139.31 187.81,140.12 188.34,140.12 188.54,140.33 188.54,141.22 188.67,141.34 189.26,141.34
GND on BOTTOM (solid shape): 191.06,100.45 191.06,99.43 190.63,99 188.34,99 188.19,99.15 188.19,99.46 189.1,100.37 190.25,100.37 190.4,100.53 190.98,100.53
GND on BOTTOM (solid shape): 99.92,209.11 99.92,200.67 99.54,200.28 97.51,200.28 95.61,202.19 88.05,202.19 85.83,199.97 83.6,199.97 83.29,200.28 83.29,208.73 83.92,209.37 99.67,209.37
GND on BOTTOM (solid shape): 176.84,135.22 178.51,135.22 180.01,136.72 184.32,136.72 184.76,136.28 184.76,134.37 184.19,133.8 172.7,133.8 172.31,134.18 172.31,136.53 172.5,136.72 175.34,136.72
GND on BOTTOM (solid shape): 120.82,121.67 120.82,118 118.19,115.37 118.19,112.73 117.81,112.35 117.32,112.35 117.02,112.65 117.01,112.65 117.01,117.02 117.89,117.91 117.89,121.16 118.53,121.8 120.69,121.8
GND on BOTTOM (solid shape): 169.84,209.05 169.84,207.14 169.33,206.63 167.11,206.63 166.44,205.97 166.44,203.94 161.33,198.82 141.14,198.82 138.28,201.68 138.28,208.92 138.79,209.43 169.46,209.43
GND on BOTTOM (solid shape): 199.43,207.33 199.43,191.78 198.98,191.33 194.98,191.33 194.67,191.65 194.67,204.35 194.09,204.92 184.19,204.92 183.36,204.09 182.09,204.09 181.01,205.17 177.9,205.17 177.01,206.06 177.01,208.92 177.52,209.43 197.33,209.43
GND on BOTTOM (solid shape): 126.12,205.77 126.13,205.76 126.33,205.4 126.66,205.16 126.66,203.71 126.28,203.33 125.51,203.33 125.2,203.65 125.2,204.6 125.11,204.69 124.05,205.75 124.05,206.57 124.31,206.83 125.07,206.83
GND on BOTTOM (solid shape): 30.28,92.02 31.22,92.02 31.85,91.38 31.22,90.75 30.28,90.75 30.28,87.57 27.08,87.57 27.08,90.75 26.14,90.75 25.5,91.38 26.14,92.02 27.08,92.02 27.08,96.46 30.28,96.46
GND on BOTTOM (solid shape): 115.48,209.05 115.48,207.65 116.31,206.83 120.63,206.83 120.94,206.51 120.94,205.75 120.5,205.3 114.21,205.3 114.11,205.36 114.12,205.46 113.33,207.05 112.54,205.46 112.55,205.36 112.46,205.3 112.24,205.3 111.97,205.03 111.95,205.02 111.49,204.76 111.22,204.29 111.22,204.28 110.4,203.46 103.67,203.46 102.4,202.19 102.4,194.89 102.02,194.51 101.13,194.51 100.81,194.82 100.81,208.98 101.26,209.43 115.1,209.43
GND on BOTTOM (solid shape): outline of 247 points within 66.25,166.36 77.59,171.21
GND on BOTTOM (solid shape): outline of 252 points within 67.15,97.01 72,108.36
GND on BOTTOM (solid shape): outline of 28976 points within 56.3,35.38 181.71,114.12
GND on PWR (solid shape): 195.56,163.1 195.56,159.88 195.39,159.71 188.17,159.71 187.43,160.45 187.43,163.03 187.66,163.26 195.39,163.26
GND on PWR (solid shape): outline of 101 points within 170.79,133.04 186.67,137.74
GND on PWR (solid shape): outline of 110 points within 131.55,149.8 135.87,163.01
GND on PWR (solid shape): outline of 107 points within 114.66,148.79 117.7,163.01
GND on PWR (solid shape): outline of 107 points within 116.23,2.53 119.94,12.08
GND on PWR (solid shape): outline of 118 points within 170.92,99.64 188.19,105.23
GND on PWR (solid shape): outline of 141 points within 171.04,148.91 186.79,156.28
GND on PWR (solid shape): outline of 143 points within 47.47,3.75 52.68,14.55
GND on PWR (solid shape): 35.99,96.84 36.63,96.84 37.13,96.34 39.04,96.34 39.22,96.16 39.22,96.01 38.66,95.45 35.84,95.45 32.67,98.62 31.67,98.62 30.97,97.92 30.87,97.89 30.8,97.96 30.58,98.34 30.2,98.57 30.2,98.57 30.2,98.4 30.16,98.32 30.08,98.3 29.95,98.32 29.82,98.3 29.73,98.32 29.69,98.4 29.69,98.57 29.69,98.57 29.08,97.88 29.41,97.03 29.44,96.91 29.35,96.84 28.01,96.84 27.91,96.91 27.95,97.03 28.28,97.88 27.66,98.57 27.66,98.57 27.66,98.4 27.62,98.32 27.54,98.3 27.41,98.32 27.28,98.3 27.19,98.32 27.15,98.4 27.15,98.57 27.09,98.55 27.06,98.55 27.03,98.56 27.02,98.6 27.03,98.63 27.97,99.56 27.97,100.45 28.42,100.91 31.93,100.91
GND on PWR (solid shape): 184.32,23.88 184.34,23.76 184.24,23.71 184.03,23.67 183.87,23.54 183.8,23.5 183.72,23.53 183.02,23.22 183.75,23 183.83,23.05 183.91,23.02 184.43,22.97 184.56,23.48 184.56,23.51 184.58,23.54 184.59,23.55 184.62,23.56 184.66,23.54 184.69,23.51 186.34,23.51 186.49,23.36 186.49,21.86 186.34,21.71 184.61,21.71 184.52,21.76 184.53,21.87 184.43,22.43 183.86,22.34 183.78,22.3 183.7,22.34 183.27,22.5 182.96,22.16 182.89,22.08 182.79,22.1 182.52,22.37 182.52,24 182.93,24.4 183.8,24.4
GND on PWR (solid shape): outline of 206 points within 112.88,157.93 121.64,169.87
GND on PWR (solid shape): outline of 221 points within 58.32,95.75 73.58,109.11
GND on PWR (solid shape): outline of 244 points within 167.41,11.3 177.09,17.67
GND on PWR (solid shape): outline of 250 points within 70.26,116.2 87.94,143.4
GND on PWR (solid shape): outline of 351 points within 183.62,132.02 190.35,144.09
GND on PWR (solid shape): outline of 352 points within 182.86,96.46 195.68,104.08
GND on PWR (solid shape): outline of 370 points within 131.17,163.31 141.2,172.03
GND on PWR (solid shape): outline of 430 points within 183.62,116.23 190.98,126.94
GND on PWR (solid shape): outline of 652 points within 55.4,26.66 108.52,32.28
GND on PWR (solid shape): outline of 788 points within 177.01,191.33 199.49,209.49
GND on PWR (solid shape): outline of 772 points within 130.79,182.36 169.9,209.49
GND on PWR (solid shape): outline of 814 points within 34.82,22.47 55.17,35.45
GND on PWR (solid shape): outline of 982 points within 121.51,20.06 141.66,34.99
GND on PWR (solid shape): outline of 1049 points within 96.75,154.5 114.15,172.54
GND on PWR (solid shape): outline of 1723 points within 82.27,181.55 103.42,209.49
GND on PWR (solid shape): outline of 1825 points within 4.34,13.33 24.82,45.1
GND on PWR (solid shape): outline of 1942 points within 170.41,35.43 199.49,209.49
GND on PWR (solid shape): outline of 2393 points within 100.81,187.14 137.77,209.49
GND on PWR (solid shape): outline of 2869 points within 140.44,164.03 185.01,192.47
GND on PWR (solid shape): outline of 3186 points within 136.3,2.53 178.61,31.9
GND on PWR (solid shape): outline of 5278 points within 12.17,154.93 83.54,198.96
GND on PWR (solid shape): outline of 14891 points within 116.43,105.1 177.9,154.93
GND on PWR (solid shape): outline of 20028 points within 54.25,35.43 189.03,116.4
GND on PWR (solid shape): outline of 22304 points within 10.31,67.94 139.93,185.95
GND on TOP: 56.85,10.03 58.17,10.03 58.33,9.86 58.33,6.67 58.4,6.61 58.4,6.29 58.2,6.1 55.79,6.1 55.54,6.36 55.54,7.63 55.73,7.82 56.62,7.82 56.68,7.88 56.68,9.86
GND on PWR: 51.22,6.17 51.03,6.35 51.03,9.74 53.17,11.88 54.59,11.88 55.6,12.9 55.6,13.53 56.49,14.42 62.46,14.42 63.6,13.28 65.38,13.28 66.02,13.91 68.2,13.91 68.56,13.55 68.56,6.35 68.37,6.17
GND on PWR: 37.92,151.12 37.52,151.52 37.52,155.69 36.74,156.47 35.22,156.47 34.82,156.86 34.82,157.88 34.19,158.51 32.82,158.51 32.42,158.91 32.42,159.89 32.44,159.92 32.47,159.94 32.79,160.59 32.07,160.46 32,160.39 31.9,160.42 31.66,160.66 31.66,161.11 31.72,161.21 31.84,161.18 32.54,161.46 31.84,161.74 31.72,161.72 31.66,161.81 31.66,162.82 31.46,163.02 31.46,163.25 32.42,164.22 32.42,165.1 32.84,165.52 39.63,165.52 40.42,164.72 43.22,164.72 43.66,165.17 44.11,165.17 45.76,163.52 45.76,152.41 44.48,151.12
GND on GND: outline of 131 points within 0.51,0.51 199.49,209.49 ; 37 cut-outs
VCC_PHASE on TOP (solid shape): 46.66,14.23 46.7,14.21 46.71,14.18 46.71,12.45 46.9,12.26 46.9,12.01 46.71,11.82 46.71,4.13 46.46,3.88 37.31,3.88 36.49,4.7 36.49,11.94 36.81,12.26 41.44,12.26 43.41,14.23
VCC_PHASE on BOTTOM (solid shape): 46.71,13.71 46.71,4.58 46.52,4.39 36.87,4.39 36.49,4.77 36.49,11.94 36.81,12.26 42.82,12.26 44.5,13.94 46.48,13.94
VCC_PHASE on PWR (solid shape): 46.71,14.17 46.71,4.07 46.52,3.88 37.22,3.88 36.42,4.67 36.42,12.14 36.55,12.26 41.41,12.26 43.44,14.29 46.59,14.29
VCC_VCC on TOP: 59.44,7.79 59.54,7.69 59.54,6.42 59.25,6.13 58.94,6.13 58.78,6.29 58.78,6.93 58.55,7.16 58.55,7.74 58.6,7.79
+ATX_3VSB on TOP (solid shape): 185.46,16.52 185.46,14.04 185.27,13.85 185.01,13.85 184.06,14.8 184.06,16.64 185.33,16.64
+ATX_3VSB on TOP (solid shape): 181.97,6.74 181.97,4.51 181.9,4.45 181.08,4.45 180.25,5.28 180.25,7.18 180.57,7.5 181.2,7.5
+ATX_3VSB on TOP (solid shape): 9.94,88.02 9.94,83.89 10.33,83.51 10.33,82.11 12.29,80.14 12.29,76.52 9.09,73.32 9.09,72.65 9.09,72.64 9.07,72.52 9.09,72.4 9.09,72.39 9.09,70.31 9.09,70.31 9.07,70.19 9.09,70.06 9.09,70.06 9.09,67.82 14.93,61.98 15.41,61.98 15.42,61.97 21.45,61.97 24.74,58.68 24.74,57.79 24.23,57.28 21.82,57.28 21.57,57.54 21.57,58.81 20.3,60.08 12.21,60.08 11.41,60.88 9.25,60.88 8.79,60.42 7.9,60.42 7.51,60.81 7.51,61.58 9.63,63.7 9.63,64.33 8.74,65.22 8.74,65.28 7.02,67 7.02,73.86 10.07,76.9 10.07,78.75 9.25,79.57 9.25,80.97 8.74,81.48 8.74,84.21 8.42,84.52 7.02,84.52 7.01,84.54 7.01,86.3 6.97,86.32 6.96,86.35 6.96,86.56 6.64,86.87 6.2,86.87 5.5,87.57 5.5,88.27 5.69,88.46 9.5,88.46
+ATX_3VSB on PWR (solid shape): outline of 4443 points within 162.97,4.82 199.49,34.69
+ATX_5VSB on TOP (solid shape): 8.74,161.8 8.74,161.17 7.15,159.58 5.88,159.58 5.56,159.9 5.56,161.74 5.82,161.99 8.55,161.99
+ATX_5VSB on TOP (solid shape): 24.87,26.05 26.54,24.38 28.05,24.38 28.36,24.07 28.36,23.18 27.86,22.69 25.77,22.69 23.5,24.96 23.5,25.93 23.98,26.41 24.87,26.41
+ATX_5VSB on TOP (solid shape): 46.6,178.49 46.6,172.6 46.46,172.46 44.96,172.46 44.9,172.52 44.9,175.25 44.9,175.26 44.9,178.5 45.14,178.73 46.36,178.73
+ATX_5VSB on TOP (solid shape): 8.99,80.97 8.99,79 8.93,78.94 8.24,78.94 7.76,78.45 7.76,77.81 6.93,76.98 6.93,74.85 6.35,74.26 4.62,74.26 4.17,74.72 4.17,77.95 4.62,78.4 5.09,78.4 5.75,79.06 5.75,80.9 5.88,81.03 8.93,81.03
+ATX_5VSB on TOP (solid shape): outline of 173 points within 51.89,4.45 93.83,26.33
+ATX_5VSB on BOTTOM (solid shape): outline of 92 points within 24.61,22.46 53.89,27.55
+DDR_VTT on TOP (solid shape): 132.18,24.9 132.18,24.14 132.88,23.44 132.88,23.18 132.69,22.99 131.67,22.99 131.55,23.12 130.91,23.75 130.91,24.33 130.91,24.34 130.91,24.96 131.04,25.09 131.99,25.09
+DDR_VTT on TOP (solid shape): 115.1,48.14 115.1,47 114.78,46.68 114.78,46.11 116.05,44.84 116.05,43 115.39,42.33 115.39,41.19 114.78,40.58 114.78,38.61 115.16,38.23 115.16,37.22 113.01,35.06 113.01,33.28 112.62,32.9 111.99,32.9 111.42,33.47 111.42,35.63 113.07,37.28 113.07,43.06 113.77,43.76 113.77,48.27 113.96,48.46 114.78,48.46
+DDR_VTT on BOTTOM (solid shape): outline of 175 points within 110.72,22.61 133.07,33.91
+DIMM_5VDUAL on TOP (solid shape): outline of 102 points within 115.1,18.29 128.31,23.82
+DVI_VGA_VCC on TOP (solid shape): 169.71,205.49 169.71,204.67 169.46,204.41 167.17,204.41 166.92,204.67 166.92,205.49 167.23,205.81 169.39,205.81
+DVI_VGA_VCC on TOP (solid shape): 130.05,197.63 130.05,193.39 129.87,193.21 126.42,193.21 126.24,193.39 126.24,195.52 126.49,195.78 127.71,195.78 127.91,195.98 127.91,197.5 128.19,197.78 129.9,197.78
+DVI_VGA_VCC_F on TOP (solid shape): 130.1,191.25 130.1,187.52 129.85,187.27 125.71,187.27 125.32,187.65 125.32,191.25 125.5,191.43 129.92,191.43
+LDOVDD on TOP (solid shape): 7.09,164.53 7.09,163.01 6.77,162.69 5.75,162.69 5.5,162.95 5.5,164.41 5.88,164.79 6.83,164.79
+LDOVDD on TOP (solid shape): 19.15,193.36 19.15,191.65 18.96,191.46 16.74,191.46 16.33,191.87 16.33,193.27 16.68,193.62 18.9,193.62
+LDOVDD on BOTTOM (solid shape): outline of 498 points within 3.72,162.82 18.64,192
+USB3VCC2_1 on TOP (solid shape): 22.26,18.8 22.26,17.64 22.24,17.62 22.24,16.05 22.14,15.94 19.98,15.94 18.9,14.86 16.15,14.86 16.04,14.87 15.93,14.86 15.66,14.86 12.96,12.17 12.96,11.59 12.23,10.86 6.58,10.86 6.01,11.44 6.01,12.9 6.13,13.02 7.15,13.02 7.6,13.47 7.6,14.29 7.79,14.49 9.58,14.49 9.7,14.61 9.88,14.61 11.95,16.68 11.96,16.68 12.06,16.75 12.13,16.85 12.13,16.86 14.33,19.06 22.01,19.06
+USB3VCC_C1 on TOP (solid shape): 175.24,201.68 175.24,200.48 174.66,199.9 173.65,199.9 173.52,200.03 173.52,201.94 173.65,202.06 174.85,202.06
+USB3VCC_C1 on TOP (solid shape): outline of 116 points within 179.43,194.44 194.41,204.79
+USB3VCC_C1 on TOP (solid shape): outline of 124 points within 93.76,178.66 100.28,200.67
+USB3VCC_C1 on BOTTOM (solid shape): outline of 312 points within 173.27,199.97 194.29,204.79
+USB3VCC_C1 on BOTTOM (solid shape): outline of 572 points within 82.27,186 100.25,201.66
+USBVCC0 on TOP (solid shape): 100.37,179.9 100.37,179.33 98.43,177.39 97.21,177.39 95.66,177.39 95.66,178.1 97.21,178.1 97.21,178.13 99.37,180.28 99.99,180.28
+USBVCC0 on TOP (solid shape): 76.3,198.44 76.3,194.38 79.1,191.59 79.1,190.06 83.41,185.74 83.41,182.57 85.26,180.73 85.26,180.71 87.14,178.83 87.14,172.03 87.01,171.9 82.08,171.9 81,172.98 81,181.23 80.46,181.77 80.46,185.46 78.33,187.58 78.33,188.28 77.09,189.53 77.09,191.05 74.27,193.87 74.27,198.34 74.65,198.72 76.02,198.72
+USBVCC0 on BOTTOM (solid shape): 76.3,198.47 76.3,194.38 79.1,191.59 79.1,190.06 83.16,186 83.16,185.24 82.53,184.6 81.38,184.6 78.33,187.65 78.33,188.28 77.06,189.55 77.06,191.08 74.27,193.87 74.27,198.34 74.65,198.72 76.05,198.72
+USBVCC0 on BOTTOM (solid shape): outline of 411 points within 86.13,170.63 100.31,180.28
+USBVCC2 on TOP (solid shape): 9.25,48.27 9.25,47.44 9.56,47.12 11.53,47.12 11.85,46.81 11.85,45.54 12.87,44.52 13.92,44.52 14.1,44.7 14.1,46.04 16.87,46.04 17.06,45.85 17.06,41.09 16.61,40.65 12.87,40.65 11.5,42.01 11.5,42.52 9.94,44.07 9.37,44.07 9.18,44.27 9.18,44.84 8.48,45.54 4.8,45.54 4.42,45.92 4.42,48.27 4.74,48.58 8.93,48.58
+V_3P3_LAN on TOP (solid shape): 50.97,173.93 51.66,173.93 52.24,173.36 52.24,170.5 52.05,170.31 51.16,170.31 50.97,170.5 50.97,171.9 50.71,172.15 49.63,172.15 49.44,172.34 47.6,172.34 47.41,172.54 47.41,173.17 48.62,174.38 50.52,174.38
+VCORE on TOP (solid shape): outline of 3596 points within 115.23,105.29 177.9,154.88
+VCORE on BOTTOM (solid shape): 168.89,145 168.89,143.1 167.46,141.67 165.25,141.67 164.36,142.56 164.36,145.51 165.56,146.7 167.18,146.7
+VCORE on BOTTOM (solid shape): 175.11,143.25 175.11,140.35 174.6,139.85 172.01,139.85 171.15,138.98 170.79,138.98 170.69,139.08 170.69,140.4 173.3,143.02 173.3,144.11 173.53,144.34 174.02,144.34
+VCORE on BOTTOM (solid shape): outline of 2679 points within 116.43,106.04 151.45,154.88
+VCORE_PH1 on TOP (solid shape): 145.52,163.26 145.83,162.95 145.83,161.87 146.72,160.98 146.72,158.86 146.46,158.59 145.34,158.59 144.96,158.21 144.96,156.99 143.61,155.64 143.55,155.64 141.64,153.74 141.64,151.33 139.68,149.36 135.36,149.36 135.23,149.48 135.23,154.82 135.29,154.88 136.12,154.88 136.63,155.39 136.63,157.42 136.12,157.93 135.29,157.93 135.23,157.99 135.23,163.33 135.29,163.39 140.12,163.39 141.64,164.92 145.52,164.92
+VCORE_PH1 on BOTTOM (solid shape): 145.58,164.6 145.58,162.12 146.72,160.98 146.72,157.97 146.43,157.68 145.64,157.68 144.98,157.02 144.98,156.95 141.68,153.64 141.68,151.45 139.64,149.42 135.55,149.42 135.23,149.74 135.23,154.69 135.42,154.88 136.12,154.88 136.63,155.39 136.63,157.49 136.06,158.06 135.42,158.06 135.23,158.25 135.23,163.26 135.36,163.39 140.12,163.39 141.64,164.92 145.26,164.92
+VCORE_PH1 on PWR (solid shape): 145.52,164.75 145.52,162.22 146.79,160.95 146.79,158.9 146.46,158.57 145.39,158.57 144.96,158.13 144.96,157.02 141.71,153.77 141.71,151.48 139.64,149.42 135.51,149.42 135.23,149.71 135.23,154.6 135.39,154.76 136.02,154.76 136.63,155.36 136.63,157.45 136.02,158.06 135.51,158.06 135.23,158.34 135.23,163.11 135.51,163.39 140.09,163.39 141.61,164.92 145.35,164.92
+VCORE_PH2 on TOP (solid shape): 126.21,163.58 126.75,163.04 128.53,163.04 128.63,163.14 128.88,163.14 129.01,163.01 129.01,162.5 129.64,161.87 130.47,161.87 130.79,161.55 130.79,158.77 130.53,158.51 128.47,158.51 128.12,158.16 128.12,156.98 126.78,155.64 125.13,155.64 124.31,154.82 124.31,150.75 122.59,149.04 118.91,149.04 118.47,149.48 118.47,163.33 118.53,163.39 121.51,163.39 122.15,164.03 122.15,165.04 122.34,165.23 126.21,165.23
+VCORE_PH2 on BOTTOM (solid shape): 126.78,163.01 128.5,163.01 129.64,161.87 130.47,161.87 130.79,161.55 130.79,157.99 130.34,157.55 128.69,157.55 126.78,155.64 125.13,155.64 124.31,154.82 124.31,150.75 122.59,149.04 118.85,149.04 118.47,149.42 118.47,163.07 118.78,163.39 121.51,163.39 122.63,164.5 125.29,164.5
+VCORE_PH2 on PWR (solid shape): 126.21,165.13 126.21,163.61 126.94,162.88 128.72,162.88 129.87,161.74 130.55,161.74 130.79,161.51 130.79,158.74 130.53,158.49 128.47,158.49 128.14,158.16 128.14,157.1 126.69,155.64 125.17,155.64 124.31,154.79 124.31,150.72 122.63,149.04 118.7,149.04 118.47,149.27 118.47,163.11 118.75,163.39 121.54,163.39 122.28,164.12 122.28,165.06 122.51,165.3 126.04,165.3
+VCORE_PH3 on TOP (solid shape): 184.63,151.39 184.63,148.41 184.89,148.15 186.47,148.15 186.47,144.85 184.63,144.85 184.63,144.21 184.51,144.09 183.81,144.09 182.86,143.13 182.86,138.94 182.41,138.5 179.24,138.5 178.98,138.75 178.98,140.89 179.53,141.43 179.53,141.83 174.85,146.5 171.17,146.5 170.66,147.01 170.66,151.39 170.73,151.45 184.57,151.45
+VCORE_PH3 on BOTTOM (solid shape): 184.63,151.39 184.63,144.91 182.86,143.13 182.86,138.88 182.47,138.5 179.11,138.5 178.66,138.94 178.66,142.69 174.98,146.37 174.98,151.07 175.36,151.45 184.57,151.45
+VCORE_PH3 on PWR (solid shape): 184.63,151.3 184.63,148.76 185.24,148.15 186.43,148.15 186.54,148.05 186.54,144.95 186.43,144.85 184.6,144.85 182.86,143.1 182.86,138.72 182.63,138.5 178.89,138.5 178.66,138.72 178.66,140.61 179.53,141.47 179.53,141.8 178.66,142.66 178.66,142.72 174.88,146.5 171.2,146.5 170.66,147.04 170.66,151.04 171.07,151.45 184.48,151.45
+VDIMM on TOP (solid shape): 111.8,71.31 111.8,65.54 111.54,65.28 110.59,65.28 110.4,65.47 110.4,71.44 110.53,71.57 111.54,71.57
+VDIMM on TOP (solid shape): 131.62,75.38 131.62,74.81 131.61,74.81 131.61,74.55 131.29,74.24 131.29,68.85 131.02,68.58 130.35,68.58 130.13,68.79 130.13,73.62 130.46,73.95 130.46,73.96 130.56,74.05 130.57,74.05 130.71,74.2 130.71,74.22 130.71,74.22 130.71,75.53 130.83,75.65 131.34,75.65
+VDIMM on TOP (solid shape): 143.23,33.98 143.23,32.45 142.72,31.95 142.72,31.95 142.72,30.68 142.72,30.68 142.72,29.34 142.72,29.34 142.72,28.07 142.72,28.07 142.72,27.31 142.72,27.31 142.72,26.1 141.8,25.18 139.52,25.18 139.17,24.83 139.17,24.14 138.34,23.31 136.06,23.31 134.28,21.53 133.52,21.53 133.39,21.66 133.39,21.98 136.56,25.15 138.09,25.15 138.6,25.66 138.6,26.17 138.72,26.29 141.01,26.29 141.71,26.99 141.71,28.33 141.71,29.66 141.71,30.93 141.71,31.69 141.71,32.96 141.71,33.98 141.96,34.23 142.98,34.23
+VDIMM on TOP (solid shape): outline of 250 points within 132.44,41.28 174.79,44.96
+VDIMM on TOP (solid shape): outline of 2709 points within 62.9,24.96 130.4,45.09
+VDIMM on BOTTOM (solid shape): 116.41,33.91 116.5,33.86 116.48,33.75 116.87,33.04 117.07,33.82 117.06,33.83 117.04,33.85 117.04,33.86 117.06,33.9 117.1,33.91 117.13,33.91 118.72,32.33 120.63,32.33 121.01,31.95 121.01,25.41 120.56,24.96 116.94,24.96 114.34,27.56 114.34,33.6 114.66,33.91
+VDIMM on PWR (solid shape): outline of 6845 points within 58.95,24.96 174.8,99.64
+VGA_VCC on TOP (solid shape): 129.87,199.59 129.87,198.72 129.18,198.04 127.91,198.04 127.56,197.68 127.56,196.23 127.42,196.09 126.43,196.09 126.24,196.28 126.24,197.81 127.33,198.9 128.02,198.9 128.32,199.21 128.7,199.21 129.21,199.71 129.74,199.71
+VGA_VCC on BOTTOM (solid shape): outline of 388 points within 111.29,197.94 130.02,202
AUGND on TOP (solid shape): outline of 125 points within 0.67,193.87 59.67,209.37
AUGND on TOP (solid shape): outline of 259 points within 31.67,195.34 40.67,204.34
AUGND on BOTTOM (solid shape): outline of 733 points within 0.67,191.46 59.67,209.37
AUGND on PWR (solid shape): outline of 4187 points within 0.51,162.76 60.55,209.49
AUGND on GND: 0.74,162.76 0.51,162.99 0.51,206.95 1.25,208.75 3.05,209.49 59.43,209.49 59.79,209.13 59.79,188.63 60.55,187.87 60.55,184 60.02,183.46 47.7,183.46 46.3,182.06 43.63,182.06 42.9,181.33 42.9,179.8 40.97,177.87 37.6,177.87 36.14,176.41 33.47,176.41 32.77,177.11 25.28,177.11 24.87,177.52 24.87,178.92 20.33,183.46 13.28,183.46 11.41,181.58 11.41,173.9 12.26,173.04 12.9,173.04 14.07,171.87 14.07,169.26 13.66,168.85 12.01,168.85 7.09,163.93 7.09,162.91 6.93,162.76
BA_PC1 on TOP (solid shape): 193.84,58.87 193.84,56.46 193.52,56.14 191.02,56.14 190.63,56.53 190.63,58.54 191.08,59 193.71,59
BZ_P on TOP (solid shape): 195.68,61.16 195.68,59.57 195.36,59.25 191.68,59.25 191.49,59.44 191.49,60.2 191.68,60.39 192.76,60.39 192.95,60.58 192.95,61.16 193.14,61.35 195.49,61.35
DPG on TOP (solid shape): 138.02,196.79 138.02,196.47 138.21,196.28 138.41,196.28 138.66,196.03 138.66,195.71 137.83,194.89 137.07,194.89 137.01,194.95 137.01,196.86 137.14,196.98 137.83,196.98
DPG on TOP (solid shape): 138.02,192.98 138.02,192.66 138.21,192.47 138.41,192.47 138.66,192.22 138.66,191.9 137.83,191.08 137.07,191.08 137.01,191.14 137.01,193.05 137.14,193.17 137.83,193.17
LPTVCC on TOP (solid shape): 152.88,13.21 152.88,12.45 151.99,11.56 151.49,11.56 150.66,12.39 150.66,13.15 150.79,13.28 152.82,13.28
LPTVCC on TOP (solid shape): 157.07,13.21 157.07,12.45 156.19,11.56 155.68,11.56 154.85,12.39 154.85,13.15 154.98,13.28 157.01,13.28
LPTVCC on TOP (solid shape): 161.07,13.21 161.07,12.45 160.19,11.56 159.68,11.56 158.85,12.39 158.85,13.15 158.98,13.28 161.01,13.28
LPTVCC on TOP (solid shape): 164.31,13.21 164.31,11.69 164.19,11.56 163.87,11.56 163.23,12.2 162.28,12.2 162.15,12.32 162.15,13.21 162.22,13.28 164.25,13.28
Net_1034 on TOP (solid shape): outline of 251 points within 81.19,72.17 89.32,80.3
Net_1034 on BOTTOM (solid shape): outline of 251 points within 81.19,72.17 89.32,80.3
Net_1039 on TOP (solid shape): outline of 250 points within 81.19,147.17 89.32,155.3
Net_1039 on BOTTOM (solid shape): outline of 250 points within 81.19,147.17 89.32,155.3
Net_1113 on TOP (solid shape): outline of 251 points within 156.2,72.17 164.33,80.3
Net_1113 on BOTTOM (solid shape): outline of 251 points within 156.2,72.17 164.33,80.3
Net_1118 on TOP (solid shape): outline of 251 points within 156.2,147.17 164.33,155.3
Net_1118 on BOTTOM (solid shape): outline of 251 points within 156.2,147.17 164.33,155.3
REGOUT_1 on TOP (solid shape): 61.13,162.57 62.14,162.57 62.76,161.94 62.76,161.26 62.46,160.95 62.46,159.45 62.33,159.33 61.63,159.33 61.44,159.52 61.44,161.42 60.91,161.96 60.91,162.58 60.96,162.63 61.06,162.63
UGND on TOP (solid shape): 82.78,208.73 82.78,199.08 81.76,198.06 81.76,194.13 83.54,192.35 83.54,187.27 83.16,186.89 82.81,186.89 79.48,190.21 79.48,191.71 76.81,194.38 76.81,196.14 81.5,196.14 81.5,199.64 79.2,199.64 79.2,196.14 76.81,196.14 76.81,198.95 76.41,199.36 69.41,199.36 68.78,198.72 68.78,195.01 67.31,193.55 64.94,193.55 63.48,192.09 63.48,189.17 62.54,188.23 61.27,188.23 60.55,188.94 60.55,196.14 64.12,196.14 64.12,199.64 61.82,199.64 61.82,196.14 60.55,196.14 60.55,209.14 60.72,209.3 82.21,209.3
UGND on BOTTOM (solid shape): outline of 288 points within 60.55,183.84 83.54,209.31
UGND on PWR (solid shape): 82.78,208.88 82.78,199.06 81.76,198.04 81.76,194.15 83.54,192.37 83.54,186.96 83.54,186.94 83.53,186.92 83.35,186.75 82.98,186.75 79.46,190.26 79.46,191.79 76.73,194.52 76.73,198.9 76.31,199.32 69.5,199.32 68.76,198.58 68.76,194.96 67.34,193.54 64.93,193.54 63.42,192.04 63.42,189.12 62.51,188.21 61.3,188.21 60.55,188.95 60.55,209.13 60.91,209.49 82.17,209.49
UGND on GND: 58.75,179.52 58.14,180.13 58.14,182.46 58.37,182.7 60.33,182.7 61.32,183.68 61.32,188.19 60.55,188.95 60.55,209.13 60.91,209.49 82.17,209.49 82.78,208.88 82.78,199.06 81.76,198.04 81.76,194.15 83.54,192.37 83.54,185.59 80.9,182.95 62.61,182.95 59.18,179.52
UP1740P_P9 on TOP (solid shape): 134.34,31.57 134.34,31.18 132.79,29.63 132.18,29.63 132.16,29.66 132.16,30.57 132.51,30.93 133.15,30.93 133.43,31.21 133.43,31.51 133.6,31.69 134.21,31.69
UP1740P_P13 on TOP (solid shape): 128.33,27.85 128.95,27.85 128.95,27.86 129.13,27.86 129.16,27.83 129.16,27.68 129.26,27.58 130.79,27.58 130.81,27.55 130.81,26.49 130.79,26.46 128.98,26.46 127.29,24.77 127.29,24.33 127.8,23.82 127.8,22.55 127.61,22.36 124.37,22.36 123.99,21.98 122.78,21.98 122.53,22.23 122.53,23.31 127.08,27.86 128.33,27.86
VR_PWM1_BST on TOP (solid shape): 140.79,168.12 140.79,167.51 140.59,167.3 138.1,167.3 138.06,167.32 138.05,167.35 138.05,168.04 138.35,168.34 140.56,168.34
VR_PWM1_LG on TOP (solid shape): 136.8,166.08 136.84,166.07 136.86,166.03 136.86,165.42 135.84,164.41 134.95,164.41 134.49,163.95 133.93,163.95 133.73,164.15 133.73,165.12 133.99,165.37 135.74,165.37 136.45,166.08
VR_PWM1_VCC on TOP (solid shape): 136.86,167.96 136.86,167.3 136.17,167.3 135.81,166.95 135.38,166.95 135.28,167.05 135.28,167.89 135.41,168.01 136.8,168.01
VR_PWM1A_BST on TOP (solid shape): 187.12,121.46 187.71,121.46 187.71,120.82 187.66,120.77 186.67,120.77 186.41,120.52 185.8,120.52 185.62,120.69 185.62,121.81 185.75,121.94 186.64,121.94
VR_PWM1A_HG on TOP (solid shape): 187.71,124.1 187.71,124.07 187.63,123.83 187.71,123.59 187.71,122.7 187.69,122.66 187.66,122.65 187.43,122.65 187.33,122.75 187.33,123.23 186.56,124 185.9,124 185.6,124.3 185.6,125.16 185.88,125.44 186.36,125.44
VR_PWM1A_LG on TOP (solid shape): 189.76,124.53 189.76,123.21 189.21,122.65 188.93,122.65 188.9,122.67 188.9,123.28 189.23,123.61 189.23,123.68 189.23,123.69 189.26,123.83 189.23,123.97 189.23,123.98 189.23,124.2 188.87,124.55 188.6,124.55 188.39,124.76 188.39,125.09 188.54,125.24 189.05,125.24
VR_PWM1A_VCC on TOP (solid shape): 190.35,121.28 190.35,120.77 190.12,120.54 189,120.54 188.93,120.62 188.93,121.43 188.95,121.46 190.17,121.46
VR_PWM2_BST on TOP (solid shape): 121.39,168.12 121.39,167.56 121.13,167.3 118.67,167.3 118.63,167.32 118.62,167.35 118.62,167.89 118.63,167.92 118.67,167.94 119.84,167.94 120.24,168.34 121.16,168.34
VR_PWM2_LG on TOP (solid shape): 117.37,166.08 117.41,166.07 117.42,166.03 117.42,165.27 117.42,165.25 117.41,165.23 117.34,165.14 117.29,165.04 117.29,165.03 116.71,164.46 116.26,164.46 116.13,164.58 116.13,165.04 116.82,165.73 116.82,165.78 116.84,165.8 116.84,165.98 116.94,166.08
VR_PWM2A_BST on TOP (solid shape): 188.42,98.77 188.42,98.14 186.77,96.49 185.73,96.49 185.34,96.87 185.34,97.73 185.67,98.06 187.07,98.06 187.81,98.8 188.39,98.8
VR_PWM2A_LG on TOP (solid shape): 190.37,101.49 190.37,101.14 190.12,100.88 190.12,100.12 189.99,99.99 189.61,99.99 189.61,101.57 189.71,101.67 190.2,101.67
VR_PWM2A_VCC on TOP (solid shape): 191.16,98.72 191.16,98.14 191.08,98.06 189.69,98.06 189.61,98.14 189.61,98.77 191.11,98.77
VR_PWM3_BST on TOP (solid shape): 186.67,138.65 187.71,138.65 187.73,138.63 187.73,138.02 187.71,137.99 186.56,137.99 186.23,137.66 185.75,137.66 185.52,137.89 185.52,138.83 185.78,139.08 186.23,139.08
VR_PWM3_HG on TOP (solid shape): 187.53,141.29 187.53,140.84 187.71,140.66 187.71,139.9 187.68,139.87 187.33,139.87 187.22,139.97 187.22,140.43 186.51,141.14 185.78,141.14 185.5,141.42 185.5,142.33 185.73,142.56 186.26,142.56
VR_PWM3_LG on TOP (solid shape): 189.81,141.65 189.81,140.45 189.23,139.87 188.98,139.87 188.94,139.89 188.93,139.92 188.93,140.51 189.26,140.84 189.26,141.37 188.8,141.83 188.29,141.83 188.14,141.98 188.14,142.31 188.27,142.44 189.03,142.44
VR_PWM3_VCC on TOP (solid shape): 190.25,138.5 190.25,137.91 190.12,137.79 189,137.79 188.93,137.86 188.93,138.63 188.95,138.65 190.09,138.65
N32196073 on TOP (solid shape): 65.95,22.17 65.95,14.86 65.86,14.77 55.82,14.77 54.97,15.63 49.12,15.63 48.55,15.06 42.65,15.06 42.39,15.31 42.39,19.25 60.41,19.25 60.41,19.17 60.43,19.08 60.45,19.01 60.47,18.93 60.51,18.86 60.55,18.79 60.6,18.72 60.66,18.66 60.72,18.61 60.78,18.56 60.85,18.52 60.93,18.49 61,18.46 61.08,18.44 61.16,18.43 61.24,18.43 61.33,18.44 61.41,18.45 61.48,18.47 61.56,18.5 61.63,18.54 61.7,18.59 61.76,18.64 61.82,18.69 61.87,18.75 61.92,18.82 61.96,18.89 61.99,18.97 62.01,19.05 62.03,19.12 62.04,19.21 62.04,19.29 62.03,19.37 62.01,19.45 61.99,19.52 61.96,19.6 61.92,19.67 61.87,19.74 61.82,19.8 61.76,19.86 61.7,19.91 61.63,19.95 61.56,19.99 61.48,20.02 61.41,20.04 61.33,20.05 61.24,20.06 61.16,20.06 61.08,20.05 61,20.03 60.93,20 60.85,19.97 60.78,19.93 60.72,19.88 60.66,19.83 60.6,19.77 60.55,19.7 60.51,19.64 60.47,19.56 60.45,19.49 60.43,19.41 60.41,19.33 60.41,19.25 42.39,19.25 42.39,19.37 45.06,22.04 49,22.04 49.63,22.68 65.44,22.68
N32208973 on TOP (solid shape): 111.67,164.5 111.67,162.06 111.16,161.55 105.99,161.55 105.45,161 103.15,161 102.95,161.21 102.95,163.04 102.96,163.07 103,163.09 103.12,163.09 103.23,163.19 103.23,164.71 103.24,164.75 103.28,164.76 104.29,164.76 104.32,164.74 104.32,163.14 104.42,163.04 104.43,163.04 104.59,162.88 108.37,162.88 110.37,164.88 111.29,164.88
N32209109 on TOP (solid shape): 102.9,166.19 102.93,166.17 102.95,166.13 102.95,163.3 102.91,163.26 102.77,163.26 102.75,163.25 102.75,163.11 102.74,163.1 102.74,160.85 104.84,158.76 108.59,158.76 108.6,158.74 109.15,158.74 109.45,158.44 109.45,155.01 109.07,154.63 100.94,154.63 100.56,155.01 100.56,159.77 100.81,160.03 100.81,162.48 101.35,163.01 101.35,166.13 101.36,166.17 101.4,166.19
N32209109 on BOTTOM (solid shape): 104.31,165.87 104.31,159.33 104.88,158.76 107.73,158.76 109.1,157.39 109.1,155.29 108.43,154.63 101.89,154.63 101.32,155.2 101.32,166.06 101.45,166.19 103.99,166.19
N32209268 on TOP (solid shape): 101.14,166.87 101.14,166.13 101.13,166.1 101.09,166.08 100.32,166.08 100.03,166.08 99.57,166.54 99.16,166.54 99.01,166.69 99.01,167.3 99.16,167.46 100.56,167.46
N32212212 on TOP (solid shape): 78.92,133.55 78.92,131.97 79.22,131.67 85.48,131.67 86.54,132.72 87.8,132.72 87.99,132.53 87.99,129.91 87.73,129.66 78.97,129.66 77.55,131.08 77.55,131.92 77.83,132.2 77.83,133.57 78.89,133.57
N32212346 on TOP (solid shape): 77.55,134.99 77.55,132.12 77.34,131.92 77.34,130.78 78.36,129.76 78.36,127.6 78.08,127.32 73.28,127.32 73.08,127.53 73.08,131.77 73.23,131.92 75.87,131.92 75.92,131.97 75.92,134.97 75.97,135.02 77.52,135.02
N32212486 on TOP (solid shape): 74.55,135.55 75.46,135.55 75.74,135.27 75.74,134.92 73.23,134.92 73.05,134.74 72.62,134.74 72.42,134.94 72.42,136.59 72.57,136.75 73.36,136.75
N32215527 on TOP (solid shape): 126.29,29.69 128.6,29.69 128.83,29.46 132.23,29.46 132.26,29.43 132.26,27.88 132.23,27.86 129.41,27.86 129.38,27.87 129.36,27.91 129.36,28.01 129.34,28.03 128.95,28.03 128.95,28.04 128.33,28.04 128.33,28.03 126.05,28.03 123.61,25.6 121.7,25.6 121.51,25.79 121.51,30.68 122.4,31.57 124.41,31.57
N32215527 on BOTTOM (solid shape): 126.21,29.72 128.56,29.72 128.82,29.47 132.18,29.47 132.25,29.41 132.25,28.01 132.12,27.88 129.39,27.88 129.2,28.07 126.15,28.07 123.74,25.66 121.7,25.66 121.51,25.85 121.51,30.68 122.4,31.57 124.37,31.57
N32242206 on TOP (solid shape): 43.97,28.42 44,28.4 44.02,28.36 44.02,28.31 44.17,28.16 45.62,28.16 45.65,28.15 45.67,28.11 45.67,27.09 45.65,27.06 45.62,27.04 44.04,27.04 43.92,26.92 43.92,26.13 43.46,25.67 42.16,25.67 41.94,25.45 41.94,24.73 42.29,24.38 43.23,24.38 43.74,23.87 43.74,22.95 43.52,22.74 38.46,22.74 37.8,22.08 37.8,18.97 37.15,18.33 34.68,18.33 33.55,19.45 33.55,19.8 33,20.36 33,21.25 34.9,23.16 34.9,25.85 35.22,26.17 39.79,26.17 41.82,28.2 42.96,28.2 43.18,28.42
N32242353 on TOP (solid shape): 47.09,28.42 44.17,28.42 44.17,28.57 44.15,28.59 43.79,28.59 43.79,28.61 43.18,28.61 43.18,28.59 41.35,28.59 39.75,26.99 35.7,26.99 35.09,27.6 35.09,29.66 35.45,30.02 47.09,30.02
N32242353 on BOTTOM (solid shape): 47.09,29.91 47.09,28.58 46.97,28.45 41.19,28.45 39.73,26.99 35.67,26.99 35.09,27.58 35.09,29.66 35.47,30.04 46.97,30.04
