# Allegro board ECS H11H4-AI-V1.0-OK.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
HDMI_SCL: length 32.6
  TOP w0.102: HDMI.15 156.23,197.09 153.33,194.19 149.96,194.19 143.91,188.14 U9.4 141.96,187.52 141.71,187.27 139.79,187.27 139.63,187.43 139.63,187.44 139.55,187.52 139.55,188.69 v1(139.04,189.2) 138.65,189.58 C59.1 R60.2 136.98,189.58 136.18,188.79 135.17,188.79 Q10.D
HDMI_SDA: length 34.5
  TOP w0.102: Q11.D 134.79,183.01 135.48,183.71 135.48,185.81 136.21,186.54 R72.2 C66.1 139.02,186.54 v1(139.04,186.56) 139.24,186.76 141.64,186.76 141.96,186.44 U9.3 142.49,185.64 150.66,193.81 153.52,193.81 156.73,197.02 HDMI.16
HDMI_TX_N0: length 6.9
  TOP w0.102: C43.2 134.87,192.53 135.57,192.53 135.75,192.34 RN4.3 136.56,192.34 136.82,192.6 136.82,193.43 136.94,193.55 138.09,193.55 138.27,193.38 138.27,192.99 138.47,192.79 138.78,192.79 139.01,192.56 CHOKE3.4
HDMI_TX_N0_R: length 16.8
  TOP w0.102: HDMI.9 153.23,198.01 153.01,197.79 153.01,196.44 152.27,195.7 149.08,195.7 146.11,192.73 144.76,192.73 144.62,192.59 U5.9 U5.2 143.06,192.59 142.85,192.8 142.29,192.8 141.98,192.5 RN5.4
HDMI_TX_N1: length 6.9
  TOP w0.102: CHOKE2.4 139.08,194.59 138.91,194.75 138.91,194.94 138.82,195.04 138.64,195.04 138.41,194.8 138.41,194.57 138.15,194.32 136.88,194.32 136.61,194.58 136.61,194.98 136.52,195.08 RN2.7 135.75,195.08 135.57,195.26 135.45,195.26 135,194.81 134.69,194.81 134.5,194.62 C31.2
HDMI_TX_N1_R: length 13.8
  TOP w0.102: HDMI.6 151.73,198 151.52,197.79 151.52,197.31 150.76,196.55 148.01,196.55 146.53,195.06 144.89,195.06 144.73,194.9 U3.6 U3.5 142.94,194.9 142.85,194.99 142.29,194.99 141.98,194.68 RN3.8
HDMI_TX_N2: length 7.2
  TOP w0.102: CHOKE1.4 139.01,196.37 138.78,196.6 138.47,196.6 138.27,196.8 138.27,197.19 138.09,197.36 136.94,197.36 136.82,197.24 136.82,196.41 136.56,196.15 RN2.3 135.75,196.15 135.57,196.34 135.35,196.34 135.16,196.53 135.16,196.73 135.04,196.86 134.88,196.86 C27.2
HDMI_TX_N2_R: length 11.3
  TOP w0.102: RN3.4 141.98,196.31 142.14,196.47 143,196.47 143.06,196.4 U3.2 U3.9 144.66,196.4 144.72,196.46 146.25,196.46 147.18,197.38 149.49,197.38 150.23,198.12 HDMI.3
HDMI_TX_P0: length 6.8
  TOP w0.102: C41.2 134.5,193.01 134.78,192.73 135.57,192.73 135.75,192.92 RN4.1 136.45,192.92 136.61,193.08 136.61,193.51 136.86,193.76 138.17,193.76 138.47,193.46 138.47,193.08 138.55,192.99 138.75,192.99 138.85,193.09 138.85,193.24 139.01,193.41 CHOKE3.1
HDMI_TX_P0_R: length 16.8
  TOP w0.102: RN5.2 141.98,193.31 142.29,193.01 142.85,193.01 142.94,193.09 U5.1 U5.10 144.59,193.09 144.76,192.93 146.03,192.93 149,195.9 152.18,195.9 152.81,196.52 152.81,197.75 152.7,197.86 152.36,197.86 152.23,197.99 HDMI.7
HDMI_TX_P1: length 7
  TOP w0.102: CHOKE2.1 139.08,195.44 138.88,195.24 138.56,195.24 138.2,194.88 138.2,194.65 138.07,194.52 136.97,194.52 136.82,194.67 136.82,195.4 136.56,195.65 RN2.5 135.75,195.65 135.57,195.47 135.37,195.47 134.91,195.01 134.66,195.01 134.5,195.17 C29.2
HDMI_TX_P1_R: length 13.9
  TOP w0.102: RN3.6 141.98,195.5 142.29,195.19 142.77,195.19 142.98,195.4 U3.4 U3.7 144.75,195.4 144.88,195.27 146.45,195.27 147.93,196.75 150.67,196.75 151.32,197.39 151.32,197.76 151.22,197.87 150.92,197.87 150.73,198.05 HDMI.4
HDMI_TX_P2: length 7.2
  TOP w0.102: CHOKE1.1 139.01,197.22 138.85,197.05 138.85,196.9 138.75,196.8 138.55,196.8 138.47,196.89 138.47,197.27 138.17,197.57 136.86,197.57 136.61,197.32 136.61,196.89 136.45,196.73 RN2.1 135.75,196.73 135.57,196.54 135.43,196.54 135.37,196.61 135.37,196.82 135.12,197.06 134.97,197.06 134.71,197.06 134.5,197.27 C15.2
HDMI_TX_P2_R: length 11.3
  TOP w0.102: HDMI.1 149.23,198.26 149.58,197.9 149.58,197.76 149.41,197.59 147.09,197.59 146.17,196.66 144.84,196.66 144.6,196.9 U3.10 U3.1 143.05,196.9 142.82,196.67 142.15,196.67 142.09,196.73 142.09,196.92 141.88,197.12 RN3.2
HDPANEL_DETECT: length 191.9
  TOP w0.089: 52.32,71.52 52.32,76.97 52.62,77.26 52.62,78.24 53.05,78.67 53.32,78.67 53.45,78.8 53.45,78.85 53.51,78.9 53.51,79.95 53.28,80.17 53.28,82.19 PCH1.R36
  TOP w0.102: R122.2 12.93,178.89 13.82,178 D11.3 v2(14.71,177.27) ; 52.32,71.52 52.32,69.42 R414.1 52.87,68.33 v2(51.79,67.25) ; v2(42.38,62.9) 42.09,63.19 31.42,63.19 30.89,63.72 28.74,63.72 26.41,66.06 25.5,66.06 24.16,64.71 14.75,64.71 v2(14.3,65.16)
  BOTTOM w0.102: v2(42.38,62.9) 42.65,63.16 47.32,63.16 v3(50.7,66.54) 51.41,67.25 v2(51.79,67.25) ; v2(14.71,177.27) 14.93,177.27 18.21,173.98 19.53,173.98 21.23,172.28 21.23,171.16 24.69,167.71 24.69,149.15 22.82,147.29 22.82,109.91 21.43,108.52 20.28,108.52 19.71,107.96 19.71,107.95 19.29,107.52 15.85,107.52 15.03,108.34 13.44,108.34 11.47,106.37 11.47,80.53 15.52,76.48 15.52,69.31 14.76,68.55 14.76,65.61 v2(14.3,65.16)
HM_5VDUAL: length 9.6
  TOP w0.203: R509.2 R508.1 191.94,27.84 189.39,27.84 C489.1 188.85,27.3 188.29,27.3 v1(187.86,27.73) 187.17,27.73 186.75,27.3 U35.90
HM_12V: length 10.1
  TOP w0.203: R485.2 v1(193.42,30.55) R484.1 191.94,31.08 189.39,31.08 C474.1 188.59,30.55 186.54,28.5 U35.93
HM_VCC: length 9.9
  TOP w0.203: R494.2 R493.1 191.93,30.02 189.4,30.02 C481.1 188.35,29.47 v1(187.88,29) 187.51,29 186.61,28.1 U35.92
HM_VCC3: length 9.6
  TOP w0.203: U35.91 186.68,27.7 187.37,28.39 C485.1 189.39,28.92 191.94,28.92 R498.1 v1(193.42,28.39) R499.2
HM_VCORE: length 8.4
  TOP w0.203: U35.95 186.39,29.3 186.96,29.86 186.96,30.47 187.92,31.44 v1(187.94,31.44) 187.94,31.79 C461.1 189.39,33.24 190.99,33.24 R475.2
HM_VDIMM: length 7.9
  TOP w0.203: R482.2 190.99,32.16 189.39,32.16 C470.1 188.86,31.28 187.8,30.22 v1(187.5,30.22) 187.33,30.05 187.33,29.76 186.48,28.9 U35.94
HSIN: length 3.5
  TOP w0.102: U19.14 57.2,163.62 57.09,163.73 56.47,163.73 55.64,162.89 55.15,162.89 C171.1
HSIP: length 3.5
  TOP w0.102: C169.1 55.15,163.1 55.55,163.1 56.39,163.93 57.11,163.93 57.19,164.02 U19.13
HSON: length 5.3
  TOP w0.102: C183.1 55.28,160.25 55.28,160.47 56.09,161.28 58.19,161.28 58.52,161.61 58.52,161.84 58.6,161.92 U19.18
HSOP: length 5.3
  TOP w0.102: U19.17 58.2,161.96 58.32,161.84 58.32,161.7 58.11,161.49 56.01,161.49 55.08,160.56 55.08,160.24 C182.1
ILAN_WAKE_L: length 179.1
  TOP w0.089: PCH1.BD11 38.37,94.95 38.17,94.74 38.16,94.74 38.14,94.73 37.8,94.73 37.73,94.8 37.68,94.8 37.67,94.81 37.25,94.81
  TOP w0.102: R226.2 59.35,155.64 57.65,153.94 50.84,153.94 47.24,150.35 30.28,150.35 25.51,155.11 23.88,155.11 v2(23.42,154.65) ; v2(11.66,74.49) 12.06,74.49 12.82,75.25 18.59,75.25 19.85,76.52 19.85,77.75 21.98,79.88 24,79.88 26.82,82.7 26.82,85.67 27.92,86.76 31.3,86.76 33.55,89.01 33.55,93.07 35.29,94.81 37.25,94.81
  BOTTOM w0.102: v2(11.66,74.49) 11.34,74.49 9.16,76.68 9.16,77.76 6.31,80.61 6.31,85.1 5.55,85.86 5.55,96.2 6.27,96.92 6.27,100.91 5.56,101.62 5.56,104.72 6.63,105.78 6.63,130.83 6.22,131.23 6.22,137.56 v3(6.63,137.97) 7.26,138.6 7.26,146.13 13.93,152.8 14.47,152.8 15.18,153.5 15.18,154.88 15.79,155.5 19.11,155.5 21.17,153.43 22.02,153.43 23.24,154.65 v2(23.42,154.65)
INT_DNOISE: length 13.3
  TOP w0.381: INT_SPK.7 6.64,167.01 6.64,170.12 8.93,172.41 Q19.C 13.25,171.58 R155.2
INT_VIN: length 7.4
  TOP w0.508: INT_SPK.8 8.58,165.8 C150.2 10.87,168.57 C141.2 R172.2
ISOLATEB: length 6.8
  TOP w0.102: R224.1 56.81,157.01 57.58,157.78 v1(57.58,157.96) 57.52,158.02 57.52,159.37 R217.1 57.95,160.07 59.4,161.52 U19.20
ITP_PMODE: length 3.3
  TOP w0.089: v4(41.76,101.54) 42.18,101.12 42.18,99.84 42.06,99.72 PCH1.AT2
  BOTTOM w0.089: v4(41.76,101.54) 41.82,101.61 STP6.1
JDREF: length 2.6
  TOP w0.254: R79.2 13.02,185.45 13.48,185.91 CODEC.40
KB_CLK: length 218
  TOP w0.102: U35.78 184.47,22.5 184.39,22.58 183.84,22.58 v2(183.36,22.1) ; v2(198.35,94.24) 198.7,94.6 198.7,168.6 195.5,171.8 190.96,171.8 186.67,176.09 186.67,186.75 178.22,195.19 174.79,195.19 171.53,198.46 171.53,200.77 171.99,201.23 RN1.6 173.14,201.23 173.33,201.43 173.33,202.19 173.52,202.38 175.04,202.38 175.81,201.62 L2.1
  BOTTOM w0.102: v2(183.36,22.1) 183.85,22.59 186.29,22.59 188.83,20.06 191.36,20.06 193.08,21.78 193.08,25.54 v3(193.59,26.04) 194.39,26.84 194.39,37.26 199.14,42.01 199.14,93.45 v2(198.35,94.24)
KB_DATA: length 216.2
  TOP w0.102: L1.1 173.39,202.95 172.69,202.25 RN1.8 172.12,201.81 171.3,200.98 171.3,198.36 174.7,194.96 178.13,194.96 186.44,186.65 186.44,176 190.86,171.57 195.25,171.57 198.48,168.34 198.48,95.51 v2(198.22,95.26) ; U35.77 v2(184.19,22.1)
  BOTTOM w0.102: v2(184.19,22.1) 186.46,22.1 188.73,19.83 191.46,19.83 193.84,22.21 v3(193.84,24.2) 194.62,24.97 194.62,37.17 199.37,41.92 199.37,94.11 v2(198.22,95.26)
KBCLK: length 9.2
  TOP w0.102: L2.2 C6.2 179.52,200.86 185.34,200.86 PSKM.5
KBDATA: length 11.9
  TOP w0.102: L1.2 C2.2 179.46,202.25 181.27,202.25 182.09,201.43 186.97,201.43 PSKM.1
KBRST_L: length 283.8
  TOP w0.102: v2(13.69,73.22) 18.58,73.22 21.12,75.76 21.98,75.76 R379.2 ; U35.42 175.24,16.71 176.7,18.17 v2(177.97,18.17)
  BOTTOM w0.102: v2(177.97,18.17) 177.46,17.66 177.46,15.82 178.66,14.61 178.66,11.37 v3(179.05,10.99) 179.05,9.78 176.06,6.8 146.52,6.8 145.54,5.82 142.46,5.82 141.34,6.94 139.99,6.94 139.29,7.64 131.73,7.64 131.03,6.94 118.85,6.94 118.5,7.3 99.07,7.3 94.92,3.15 70.21,3.15 67.2,6.17 64.87,6.17 64.17,6.87 62.2,6.87 57.95,11.12 57.48,11.12 56.36,12.24 56.36,12.83 54.57,14.62 43.96,14.62 42.41,13.07 36.08,13.07 30.57,7.56 26.75,7.56 25.78,8.54 23.04,8.54 21.13,6.62 19.8,6.62 17.79,6.62 16.61,7.8 15.37,7.8 12.25,4.68 9.53,4.68 6.61,7.6 6.07,8.13 6.07,8.13 3.33,10.88 3.33,47.76 6.52,50.95 6.52,56.9 12.45,62.83 12.45,67.54 13.23,68.32 13.23,69.25 14,70.01 14,72.92 v2(13.69,73.22)
KBRST_L_RC: length 31.5
  TOP w0.089: v4(41.8,92.73) 42.13,92.4 PCH1.AT17
  TOP w0.102: v2(23.85,78.12) 23.85,77.92 23.12,77.19 C360.1 R379.1 R382.1
  BOTTOM w0.102: v2(23.85,78.12) v3(23.85,79.14) 23.85,79.7 24.99,80.84 24.99,84.73 26.37,86.1 31.19,86.1 37.01,91.92 39.5,91.92 39.7,92.12 41.18,92.12 v4(41.8,92.73)
LAN1_RSET: length 2.3
  TOP w0.102: U19.31 62.05,165.22 63.02,166.19 R186.2
LAN_DIS_L: length 54.9
  TOP w0.089: v4(43.18,93.78) 42.92,93.52 PCH1.AR15
  TOP w0.102: R402.1 22.05,70.48 20.12,70.48 v2(19.72,70.87)
  BOTTOM w0.089: 31.26,99.09 35.61,94.74 39.8,94.74 40.23,94.3 40.65,94.3 40.73,94.22 42.73,94.22 v4(43.18,93.78)
  BOTTOM w0.102: 31.26,99.09 30.81,99.54 29.98,100.37 29.9,100.45 27.31,100.45 24.69,97.83 24.69,86.99 22.45,84.75 22.45,81.15 19.71,78.4 v3(19.71,77.56) 19.41,77.26 19.41,71.19 v2(19.72,70.87)
LAN_LED0: length 48.8
  TOP w0.102: R129.1 61.82,178 v2(62.08,178.25) ; v2(68.68,161.42) 67.96,162.15 63.47,162.15 62.57,163.04 62,163.62 U19.27
  BOTTOM w0.102: v2(68.68,161.42) 69.42,161.42 73.23,165.23 76.85,165.23 79.92,168.31 79.92,173.4 74.18,179.14 v3(64.03,179.14) 62.97,179.14 v2(62.08,178.25)
LAN_LED1: length 49.1
  TOP w0.102: v2(64.81,178.06) 65.48,177.39 R131.1 65.94,177.82 65.94,179.06 C104.1 65.51,180.22 65.92,180.63 R107.1 ; v2(67.77,161.45) 67.3,161.92 63.37,161.92 62.07,163.22 U19.26
  BOTTOM w0.102: v2(67.77,161.45) 68.75,162.43 v3(69.16,162.43) 70.09,162.43 73.13,165.46 76.72,165.46 79.53,168.27 79.53,173.37 74.02,178.89 65.63,178.89 v2(64.81,178.06)
LAN_LED1_1G_R: length 6.7
  TOP w0.102: USB2_LAN.12 66.27,184.41 R107.2 66.78,181.08 D10.N
LAN_LED2: length 372
  TOP w0.102: v2(78.72,176.85) 78.14,177.42 78.14,177.96 R120.1 ; U19.25 62.15,162.82 63.33,161.64 66.61,161.64 v2(66.88,161.37) 66.88,159.75 60.83,153.7 50.95,153.7 47.37,150.12 30.18,150.12 25.67,154.63 v2(24.17,154.63) ; v4(115.55,9.21) 115.42,9.34 Q67.B
  BOTTOM w0.102: v4(115.55,9.21) 115.28,8.95 98.53,8.95 96.83,7.24 68.41,7.24 66.44,9.21 65.38,9.21 64.87,9.72 v3(64.24,9.72) 63.8,9.29 61.42,9.29 59.49,11.22 59.49,12.49 58.87,13.11 57.6,13.11 55.17,15.54 43.58,15.54 42.12,14.08 35.61,14.08 31.52,9.99 30.99,9.45 30.98,9.45 30.02,8.49 27.22,8.49 26.25,9.45 22.67,9.45 20.75,7.54 20.18,7.54 18.26,7.54 17.08,8.72 12.9,8.72 12.19,9.43 6.61,9.43 4.62,11.42 4.62,35.77 6.57,37.72 6.57,48.7 10.72,52.85 10.72,55.86 11.48,56.62 11.48,59.89 13.37,61.78 13.37,66.36 13.92,66.91 13.92,68.9 14.68,69.66 14.68,75.38 14.26,75.79 14.26,76.55 13.64,77.17 12.9,77.17 12.33,77.74 12.33,78.48 10.56,80.25 9.52,80.25 8.99,80.78 8.99,85.54 7.58,86.95 7.58,94.94 8.26,95.61 8.26,101.71 8.97,102.42 8.97,113.13 9.4,113.56 9.4,117.86 8.74,118.52 8.74,129.39 9.4,130.05 9.4,135.83 10.03,136.47 10.03,142.46 10.83,143.26 12.04,143.26 12.71,142.59 14.73,142.59 15.66,143.52 19.09,143.52 20.04,144.47 20.74,144.47 21.44,145.17 21.44,146.63 23.77,148.96 23.77,149.9 23.42,150.26 23.42,151.85 24.42,152.85 24.42,154.37 v2(24.17,154.63) ; v2(66.88,161.37) 67.4,160.85 69.2,160.85 73.36,165 76.95,165 80.24,168.29 80.24,175.33 v2(78.72,176.85)
LAN_LED2_100M_R: length 11.8
  TOP w0.102: USB2_LAN.11 64.17,184.86 64.17,183.33 63.09,182.25 C95.1 62.66,181.15 62.66,179.7 62.97,179.39 D9.N 64.11,177.86 R130.1 63.16,176.44 R129.2
LAN_UGND: length 7
  TOP w0.508: USB2_LAN.P10 77.37,185.18 78.72,183.84 R108.2
LINE1_JD: length 38.4
  TOP w0.254: AUDIO.33 49.36,194.32 47.79,194.32 46.33,192.86 46.33,189.94 43.85,187.46 43.85,186.08 43.47,185.7 43.47,183.65 42.51,182.68 42.51,179.85 40.86,178.2 26.85,178.2 R114.2
LINE1_L: length 38.9
  TOP w0.254: L8.1 44.9,185.2 R95.1 44.43,184.16 v2(44.17,184.41) ; Q7.C1 19.31,199.09 19.27,199.05 19.25,199.05 19.03,198.83 19.03,197.41 19.3,197.14 21.17,197.14 22.38,198.35 26.8,198.35 27.03,198.12 27.03,197.14 R25.2 27.88,197.01 v2(28.11,197.24)
  BOTTOM w0.254: v2(28.11,197.24) 32.23,193.11 32.23,192.69 33.53,191.39 40.32,191.39 43.66,188.05 v3(43.66,187.27) 43.66,184.92 v2(44.17,184.41)
LINE1_L1: length 8.2
  TOP w0.254: C37.2 26.65,192.37 26.65,191.46 v3(25.5,190.32) 24.49,189.3 24.49,187.58 23.82,186.91 CODEC.23
LINE1_L2: length 1.4
  TOP w0.254: R25.1 C37.1
LINE1_L_P: length 2.6
  TOP w0.254: R13.2 v3(16.71,198.89) 16.71,198.67 16.93,198.44 Q7.B1
LINE1_LL: length 9.4
  TOP w0.254: AUDIO.34 48.34,188.94 47.17,187.78 D6.2 46.47,186.62 46.11,186.98 C72.1 44.77,186.98 L8.2
LINE1_R: length 45.1
  TOP w0.254: L10.1 51.55,184.98 51.35,184.78 R93.1 51.64,184.19 52.11,184.66 v2(52.43,184.66) ; v2(26.14,197.43) 25.69,196.98 25.22,196.98 R26.2 24.3,197.84 22.59,197.84 21.38,196.63 19.09,196.63 18.53,197.2 18.53,197.48 18.21,197.79 Q7.C2
  BOTTOM w0.254: v2(52.43,184.66) 50.27,186.82 v3(49.57,186.82) 46.33,186.82 41.25,191.9 33.74,191.9 32.74,192.9 32.74,193.57 28.39,197.92 26.63,197.92 v2(26.14,197.43)
LINE1_R1: length 6.8
  TOP w0.254: CODEC.24 23.76,187.49 23.98,187.71 23.98,190 25.18,191.2 C36.2
LINE1_R2: length 1.3
  TOP w0.254: C36.1 R26.1
LINE1_R_P: length 3.5
  TOP w0.254: R14.2 20.55,200.16 20.93,199.78 v3(20.93,199.46) 20.93,198.95 20.42,198.44 Q7.B2
LINE1_RR: length 13.8
  TOP w0.254: AUDIO.31 55.84,191.63 54.39,190.19 50.84,190.19 49.07,188.42 D6.1 49.87,186.62 50.26,187.01 C70.1 51.39,187.01 L10.2
LINE2_JD: length 30.9
  TOP w0.254: R39.1 v2(13.25,194.06)
  BOTTOM w0.254: v2(13.25,194.06) 12.48,194.82 10.18,194.82 9.67,194.32 4.17,194.32 2.71,192.86 2.71,181.3 4.61,179.39 6.71,179.39 7.98,178.12
LINE2_L: length 85
  TOP w0.254: Q2.C1 v2(15.2,204.16) ; 5.44,178.12 4.86,178.12 2.2,180.79 2.2,198 3.34,199.14 D1.2 8.58,199.14 C14.2 R20.1 v2(10.67,199.3) ; R89.2 v2(35.98,185.93)
  BOTTOM w0.254: v2(10.67,199.3) 10.67,199.62 15.2,204.14 v2(15.2,204.16) 15.22,204.16 16.54,205.48 27.97,205.48 28.84,204.61 28.84,203.05 27.85,202.07 27.85,200.83 24.94,197.92 24.94,196.93 25.83,196.04 27.39,196.04 33.06,190.38 37.04,190.38 38.88,188.53 38.88,187.27 37.74,186.12 36.17,186.12 v2(35.98,185.93)
LINE2_L1: length 16.4
  TOP w0.254: CODEC.14 23.99,182.41 25.36,181.04 28.88,181.04 30.2,179.73 36.65,179.73 EC5.1
LINE2_L2: length 5.6
  TOP w0.254: R89.1 37.13,184 39.24,181.89 EC5.2
LINE2_L_P: length 3.6
  TOP w0.254: Q2.B1 13.82,202.76 14.07,203.02 v3(14.07,204.41) 14.07,204.54 13.47,205.14 R3.2
LINE2_R: length 78.2
  TOP w0.254: R88.2 v2(34.84,186) ; Q2.C2 v2(14.2,202.11) ; v2(10.74,197.14) R24.1 C26.2 8.64,197.24 D1.1 4.11,197.24 2.83,195.97 2.83,185.81 F_AUDIO.5
  BOTTOM w0.254: v2(34.84,186) 35.54,186.7 37.59,186.7 38.38,187.48 38.38,188.32 36.83,189.87 32.84,189.87 27.18,195.53 25.62,195.53 24.44,196.72 24.44,198.18 27.34,201.09 27.34,202.28 28.33,203.26 28.33,204.39 27.75,204.97 17.06,204.97 v2(14.2,202.11) 13.89,202.11 11.42,199.65 11.42,197.82 v2(10.74,197.14)
LINE2_R1: length 8.6
  TOP w0.254: EC4.1 30.54,180.85 29.84,181.55 25.57,181.55 24.2,182.91 CODEC.15
LINE2_R2: length 3.8
  TOP w0.254: R88.1 33.17,182.33 EC4.2
LINE2_R_P: length 3.5
  TOP w0.254: R4.2 15.56,204.89 v3(16.1,204.35) 16.1,203.19 15.72,202.81 15.72,202.76 Q2.B2
LPC_DRQ0_L: length 2.7
  TOP w0.102: R491.1 168.3,29.66 v1(168.51,29.46) 168.66,29.3 U35.2
LPC_FRAME_L: length 269.7
  TOP w0.089: PCH1.BE16 36.64,92.67 35.47,91.51 35.47,88.6 33.71,86.84 33.71,85.54 32.02,83.85
  TOP w0.102: v4(31.5,83.11) 31.5,83.33 32.02,83.85 ; v2(173.46,17.09) 173.24,16.87 U35.37 ; v2(120.43,13.61) 120.82,13.23 120.82,9.47 120.37,9.02 120.37,3.37 TCM.3
  BOTTOM w0.102: v2(173.46,17.09) 173.46,16.2 171.9,14.64 170.31,14.64 168.31,12.64 150.26,12.64 145.18,17.72 136.81,17.72 132.38,13.29 120.75,13.29 v2(120.43,13.61) 119.33,13.61 117.68,15.26 94.56,15.26 93.24,16.58 68.68,16.58 63.81,21.46 56.35,21.46 54.65,19.75 41.56,19.75 40.24,18.44 33.83,18.44 31.5,16.11 18.99,16.11 15.19,19.91 15.19,34.34 18.64,37.79 18.64,49.66 26.16,57.18 29.92,57.18 30.8,58.06 30.8,67.69 32.06,68.94 32.06,79.32 31.17,80.21 31.17,82.78 v4(31.5,83.11)
LPC_LAD0: length 273.8
  TOP w0.089: PCH1.AT22 42,89.97 v4(42,90.4)
  TOP w0.102: U35.38 173.64,16.58 173.98,16.93 173.98,17.58 v2(173.27,18.29) ; TCM.11 129.71,4.2 129.71,6.48 130.91,7.69 130.91,10.17 127.42,13.66 v2(127.42,14.55)
  BOTTOM w0.089: v4(42,90.4) 41.1,89.5 38.96,89.5 37.59,88.13 36.14,88.13 32.84,84.83 32.84,84.57
  BOTTOM w0.102: v2(173.27,18.29) 172.75,17.77 171.67,17.77 169.99,16.09 169.99,15.34 167.98,13.33 150.54,13.33 145.37,18.5 136.58,18.5 132.82,14.74 127.61,14.74 v2(127.42,14.55) 123.74,14.55 123.17,13.98 121.63,13.98 121.01,14.6 119.31,14.6 117.97,15.94 94.93,15.94 88.74,22.14 55.96,22.14 54.25,20.44 41.22,20.44 39.94,19.16 33.42,19.16 31.09,16.83 19.24,16.83 15.88,20.2 15.88,34 19.41,37.53 19.41,49.45 24.31,54.36 28.28,54.36 31.8,57.89 31.8,60.29 33.35,61.84 33.35,65.68 32.97,66.06 32.97,66.07 32.84,66.19 32.84,84.57
LPC_LAD1: length 269.9
  TOP w0.089: PCH1.AV22 41.36,89.85 v4(41.36,90.38)
  TOP w0.102: TCM.10 127.17,6.74 127.17,11.18 125.26,13.09 v2(125.26,14) ; v2(174.03,18.29) 174.21,18.11 174.21,16.81 174.04,16.64 U35.39
  BOTTOM w0.089: v4(41.36,90.38) 40.71,89.72 38.88,89.72 37.52,88.36 36.09,88.36 32.61,84.88 32.61,83.76
  BOTTOM w0.102: 32.61,83.76 32.61,68.4 31.26,67.05 31.26,57.67 28.22,54.63 24.26,54.63 19.15,49.52 19.15,37.65 15.65,34.15 15.65,20.1 19.18,16.57 31.15,16.57 33.49,18.91 40.06,18.91 41.36,20.21 54.41,20.21 56.11,21.91 88.63,21.91 94.83,15.72 117.87,15.72 119.22,14.37 120.91,14.37 121.53,13.75 123.36,13.75 123.93,14.32 124.94,14.32 v2(125.26,14) 127.78,14 128.28,14.51 132.95,14.51 136.71,18.27 145.28,18.27 150.45,13.1 168.07,13.1 170.38,15.4 171.45,15.4 172.75,16.7 172.75,17.38 173.16,17.8 173.53,17.8 v2(174.03,18.29)
LPC_LAD2: length 272.7
  TOP w0.089: PCH1.AT19 42.13,90.88 v4(42.65,90.37)
  TOP w0.102: U35.40 174.44,17.94 v2(174.79,18.29) ; TCM.8 126.71,7.04 126.71,9.92 v2(122.09,14.55)
  BOTTOM w0.089: v4(42.65,90.37) 42.19,89.91 41.86,89.91 41.26,89.31 39.11,89.31 37.73,87.93 36.25,87.93 33.07,84.75 33.07,84.4
  BOTTOM w0.102: 33.07,84.4 33.07,66.29 33.58,65.78 33.58,61.74 32.06,60.22 32.06,57.82 28.35,54.11 24.49,54.11 19.63,49.26 19.63,37.43 16.1,33.9 16.1,20.29 19.33,17.06 30.96,17.06 33.32,19.42 39.87,19.42 41.12,20.67 54.1,20.67 55.8,22.37 88.85,22.37 95.05,16.17 118.06,16.17 119.41,14.83 121.1,14.83 121.38,14.55 v2(122.09,14.55) 122.34,14.8 125.85,14.8 127.69,16.64 134.35,16.64 136.44,18.73 145.47,18.73 150.64,13.56 167.77,13.56 169.71,15.5 169.71,16.13 171.58,18 172.21,18 172.99,18.78 174.31,18.78 v2(174.79,18.29)
LPC_LAD3: length 272.4
  TOP w0.089: PCH1.BD16 38.35,92.67 38.13,92.45 36.86,92.45 35.73,91.32 35.73,88.58 33.9,86.75 33.9,85.45 32.16,83.71 v4(32.16,83.13)
  TOP w0.102: v2(124.5,13.84) 124.5,13.28 126.94,10.84 126.94,4.73 TCM.7 ; U35.41 174.84,17.2 v2(174.98,17.34)
  BOTTOM w0.102: v4(32.16,83.13) 32.28,83 32.28,68.81 31.03,67.56 31.03,57.89 30.02,56.88 26.18,56.88 18.9,49.59 18.9,37.72 15.42,34.24 15.42,20.01 19.09,16.34 31.25,16.34 33.58,18.67 40.15,18.67 41.46,19.98 54.56,19.98 56.26,21.68 64.19,21.68 69.04,16.83 93.37,16.83 94.72,15.49 117.78,15.49 119.12,14.14 120.82,14.14 121.06,13.9 121.44,13.52 123.71,13.52 124.03,13.84 v2(124.5,13.84) 124.82,13.52 127.62,13.52 128.38,14.28 133.05,14.28 136.72,17.95 145.27,17.95 150.35,12.87 168.22,12.87 170.41,15.06 171.43,15.06 172.97,16.6 172.97,17.29 173.26,17.57 174.75,17.57 v2(174.98,17.34)
LPC_PIRQ_L: length 34.5
  TOP w0.089: v4(41.01,92.83) PCH1.AW17
  TOP w0.102: R384.1 22.55,74.36 21.5,74.36 v2(21.31,74.55)
  BOTTOM w0.102: v2(21.31,74.55) 21.7,74.55 v3(22.3,75.15) 23.19,76.04 23.19,79.57 24.61,80.99 24.61,84.85 26.21,86.45 31.01,86.45 36.73,92.17 39.22,92.17 39.44,92.39 40.57,92.39 v4(41.01,92.83)
LPC_PME_L: length 203.3
  TOP w0.089: 51.13,75.18 51.13,77.08 50.83,77.39 50.83,78.51 50.87,78.55 50.87,78.85 PCH1.W44
  TOP w0.102: v2(54.14,55.38) 53.32,56.2 53.32,57.16 52.43,58.04 52.43,59.12 53.49,60.19 53.49,63.72 52.27,64.94 51.46,64.94 50.95,65.45 50.95,69.84 51.13,70.02 51.13,75.18 ; v2(161.27,29.15) 161.74,28.68 R505.1 ; v2(173.2,29.47) 172.73,29 172.73,25 174.68,23.06 177.84,23.06 180.63,20.26 182.67,20.26 183.75,19.18 184.57,19.18 184.69,19.3 U35.70
  BOTTOM w0.102: v2(173.2,29.47) 172.36,29.47 171.9,29.01 v3(170.33,29.01) 170.09,29.25 168.62,29.25 168.34,28.97 168.34,28.55 167.92,28.12 166.95,28.12 166.18,28.9 161.52,28.9 v2(161.27,29.15) 158.34,29.15 156.72,27.53 146.18,27.53 142.5,23.84 136.32,23.84 133.78,21.3 129.29,21.3 127.89,19.91 120.1,19.91 119.33,19.14 114.76,19.14 113.77,20.14 113.77,21.21 112.88,22.1 96.3,22.1 91.69,26.71 91.69,28.87 85.93,34.64 57.28,34.64 56.65,35.27 55.82,35.27 54.99,36.11 54.99,36.93 54.22,37.7 54.22,38.76 55.06,39.6 55.06,40.66 54.22,41.5 54.22,42.3 53.37,43.15 53.37,46.74 52.52,47.59 52.52,48.33 53.34,49.15 53.34,50.52 52.2,51.66 52.2,53.95 53.63,55.38 v2(54.14,55.38)
LPCPD_L: length 259.6
  TOP w0.089: PCH1.BC18 38.93,91.54 38.68,91.3 38.2,91.3 38.13,91.22 37.58,91.22 36.49,90.13 36.49,88.5 34.47,86.48 34.47,84.99 34.27,84.79 34.27,82.24 33.53,81.51 33.53,80.99 32.39,79.85 32.02,79.85
  TOP w0.102: v2(141.58,7.87) 141.58,8.2 141.04,8.74 R600.2 ; v2(13.18,67.19) 13.58,66.79 23.97,66.79 25.5,68.33 25.5,69.33 27.81,71.65 27.81,78.2 29.46,79.85 32.02,79.85
  BOTTOM w0.102: v2(141.58,7.87) 141.35,8.1 131.54,8.1 130.84,7.4 119.04,7.4 118.68,7.75 98.88,7.75 94.91,3.78 82.84,3.78 81.99,4.63 69.45,4.63 66.42,7.66 62.84,7.66 v3(62.36,8.15) 61.62,8.15 58.84,10.93 58.84,12.2 58.5,12.54 57.36,12.54 54.82,15.08 43.77,15.08 42.25,13.56 35.81,13.56 30.29,8.03 27.03,8.03 26.5,8.56 26.06,9 22.85,9 20.94,7.08 19.99,7.08 18.01,7.08 16.83,8.26 15.18,8.26 12.11,5.19 9.67,5.19 8.38,6.47 6.34,8.51 6.26,8.59 6.26,8.59 3.78,11.07 3.78,47.31 10.26,53.79 10.26,56.05 11.02,56.81 11.02,60.08 12.92,61.97 12.92,66.92 v2(13.18,67.19)
LPT_ACK_L: length 49.5
  TOP w0.102: v2(177.97,25.53) 178.41,25.98 180,25.98 181.24,27.22 U35.104 ; LPT.10 168.44,4.51 168.44,6.23 167.5,7.17 162.92,7.17 162.26,7.84 162.26,10.2 162.73,10.67 CN4.2 162.97,11.26 162.54,11.69 162.09,11.69 161.71,12.07 161.71,13.72 162.09,14.11 RN21.7 162.41,14.67 162.03,15.06 v2(162.03,17.72)
  BOTTOM w0.102: v2(162.03,17.72) 162.03,18.29 164.26,20.52 167.74,20.52 169.49,22.27 171.91,22.27 174.79,25.15 177.58,25.15 v2(177.97,25.53)
LPT_AFD_L: length 35.8
  TOP w0.102: v2(151.61,17.79) 151.55,17.85 RN15.5 ; v2(179.24,29.03) 179.72,29.51 179.72,30.05 179.64,30.13 U35.108
  BOTTOM w0.102: v2(179.24,29.03) 177.15,29.03 176.47,28.35 172.72,28.35 170.37,26 167.64,26 166.88,25.24 164.95,25.24 162.17,22.47 159.56,22.47 156.73,19.64 153.35,19.64 v3(152.55,18.84) 151.61,17.9 v2(151.61,17.79)
LPT_BUSY: length 52.9
  TOP w0.102: v2(162.73,18.17) 162.6,18.04 162.6,15.06 162.98,14.67 RN21.5 162.98,13.59 162.88,13.5 162.12,13.5 161.94,13.32 161.94,12.22 162.15,12.01 162.92,12.01 163.78,11.14 CN4.4 163.78,10.14 163.56,9.92 162.74,9.92 162.48,9.67 162.48,7.93 163.02,7.4 167.62,7.4 168.69,6.32 168.69,5.34 169.46,4.58 170.92,4.58 LPT.11 ; U35.103 181.64,26.86 180.25,25.47 v2(178.85,25.47)
  BOTTOM w0.102: v2(162.73,18.17) 162.73,18.61 164.41,20.29 167.84,20.29 169.56,22.01 172.03,22.01 174.92,24.9 178.28,24.9 v2(178.85,25.47)
LPT_D0: length 36.1
  TOP w0.102: RN15.3 152.05,17.46 v2(152.38,17.79) ; v2(179.24,28.14) 178.75,28.62 178.75,30.05 178.84,30.13 U35.110
  BOTTOM w0.102: v2(152.38,17.79) 154,19.41 156.86,19.41 159.64,22.19 162.26,22.19 165.08,25.01 167.01,25.01 167.77,25.77 170.47,25.77 172.82,28.12 177.28,28.12 v3(177.6,28.44) 177.93,28.77 178.6,28.77 v2(179.24,28.14)
LPT_D1: length 33.8
  TOP w0.102: v2(153.14,17.79) 152.63,17.28 RN15.1 ; U35.111 v2(178.44,28.14)
  BOTTOM w0.102: v2(153.14,17.79) 154.53,19.18 156.99,19.18 159.08,21.28 v3(161.16,21.28) 161.72,21.28 165.23,24.78 167.2,24.78 167.96,25.55 170.61,25.55 172.95,27.88 178.18,27.88 v2(178.44,28.14)
LPT_D2: length 33.1
  TOP w0.102: v2(178.66,26.55) 177.96,27.26 177.96,30.21 178.04,30.3 U35.112 ; v2(155.61,17.79) 155.74,17.65 RN16.5
  BOTTOM w0.102: v2(155.61,17.79) 156.32,18.5 157.43,18.5 158.81,19.88 v3(159.36,19.88) 161.29,19.88 164.72,23.31 166.78,23.31 168.31,24.83 170.87,24.83 173.15,27.12 178.09,27.12 v2(178.66,26.55)
LPT_D3: length 30
  TOP w0.102: v2(177.27,26.36) 177.64,26.73 U35.113 ; RN16.1 156.82,17.47 v2(157.14,17.79)
  BOTTOM w0.102: v2(177.27,26.36) 176.96,26.66 173.34,26.66 171.06,24.38 169.22,24.38 v3(168.15,23.31) 167.53,23.31 166.09,21.86 163.92,21.86 161.12,19.06 158.81,19.06 157.53,17.79 v2(157.14,17.79)
LPT_D4: length 27.8
  TOP w0.102: v2(176.51,26.17) 176.51,26.99 177.24,27.73 U35.114 ; v2(158.85,17.79) 159.17,17.47 RN17.7
  BOTTOM w0.102: v2(176.51,26.17) 176.24,26.43 173.44,26.43 170.54,23.54 v3(169.88,23.54) 169.52,23.18 169,23.18 168.21,22.39 166.94,22.39 166.18,21.63 164.02,21.63 161.22,18.83 159.9,18.83 v2(158.85,17.79)
LPT_D5: length 26.5
  TOP w0.102: v2(159.61,17.79) 159.75,17.65 RN17.5 ; v2(175.74,25.91) 175.74,26.8 176.84,27.9 U35.115
  BOTTOM w0.102: v2(175.74,25.91) 175.45,26.21 173.53,26.21 170.28,22.95 169.1,22.95 167.9,21.76 v3(167.36,21.76) 167.01,21.41 164.11,21.41 161.29,18.58 160.41,18.58 v2(159.61,17.79)
LPT_D6: length 25.4
  TOP w0.102: v2(160.38,17.79) 160.25,17.65 RN17.3 ; U35.116 176.44,30.24 176.54,30.14 176.54,28.17 174.98,26.61 v2(174.98,25.72)
  BOTTOM w0.102: v2(174.98,25.72) 173.51,25.72 171.68,23.89 v3(171.68,23.28) 171.12,22.73 169.19,22.73 167.55,21.09 164.12,21.09 161.35,18.33 160.92,18.33 v2(160.38,17.79)
LPT_D7: length 24.4
  TOP w0.102: v2(161.14,17.79) 160.82,17.47 RN17.1 ; U35.117 176.04,30.32 176.31,30.04 176.31,28.33 174.09,26.1 v2(174.09,25.22)
  BOTTOM w0.102: v2(161.14,17.79) 164.12,20.77 167.62,20.77 169.34,22.5 171.81,22.5 173.2,23.89 v3(173.2,24.43) 173.99,25.22 v2(174.09,25.22)
LPT_ERR_L: length 50.5
  TOP w0.102: U35.107 180.04,29.47 179.87,29.3 179.87,28.33 v2(180.06,28.14) ; v2(153.96,17.79) 153.96,15.88 152.63,14.55 RN18.1 152.94,14.11 153.33,13.72 153.33,11.82 153.02,11.51 CN1.8 153.45,10.67 153.77,10.36 153.77,7.88 152.95,7.05 150.53,7.05 LPT.15
  BOTTOM w0.102: v2(153.96,17.79) 155.13,18.95 157.18,18.95 158.92,20.69 161.46,20.69 165.32,24.55 167.31,24.55 168.07,25.32 170.7,25.32 173.02,27.63 179.55,27.63 v2(180.06,28.14)
LPT_INIT_L: length 34.6
  TOP w0.102: v2(154.85,17.79) 155.17,17.47 RN16.7 ; U35.106 v2(180.44,29.03)
  BOTTOM w0.102: v2(154.85,17.79) 155.79,18.73 157.3,18.73 159.02,20.44 161.53,20.44 165.42,24.33 167.48,24.33 168.21,25.06 170.77,25.06 173.06,27.35 178.49,27.35 178.61,27.22 v3(180.11,27.22) 180.54,27.65 180.54,28.92 v2(180.44,29.03)
LPT_PE: length 50.7
  TOP w0.102: LPT.12 173.46,4.58 173.46,5.97 172.68,6.75 168.68,6.75 167.81,7.63 166.35,7.63 165.89,8.08 165.89,9.67 165.78,9.77 165.02,9.77 164.59,10.2 CN4.6 164.59,13.25 164.35,13.5 163.65,13.5 163.48,13.66 RN21.3 163.48,14.68 163.3,14.86 v2(163.3,17.66) ; v2(178.85,24.64) 179.43,25.22 180.38,25.22 182.04,26.87 U35.102
  BOTTOM w0.102: v2(163.3,17.66) 163.3,18.8 164.51,20.01 167.99,20.01 169.77,21.79 172.19,21.79 175.04,24.64 v2(178.85,24.64)
LPT_SLCT: length 51.7
  TOP w0.102: U35.101 182.44,26.89 180.12,24.58 v2(179.68,24.58) ; LPT.13 176,4.58 174.47,4.58 173.71,5.34 173.71,6.1 172.83,6.98 168.81,6.98 167.93,7.85 166.44,7.85 166.12,8.18 166.12,9.76 165.88,10 165.62,10 165.41,10.22 CN4.8 165.41,11.04 164.82,11.63 164.82,13.59 164.31,14.11 RN21.1 164.06,18.42 v2(163.93,18.55)
  BOTTOM w0.102: v2(163.93,18.55) 163.93,18.93 164.79,19.78 168.09,19.78 169.86,21.56 172.34,21.56 174.92,24.14 179.24,24.14 v2(179.68,24.58)
LPT_SLIN_L: length 34.5
  TOP w0.102: v2(179.43,26.55) 180.12,26.55 181.01,27.43 181.01,29.43 180.84,29.6 U35.105 ; RN16.3 156.24,17.65 v2(156.38,17.79)
  BOTTOM w0.102: v2(156.38,17.79) 156.86,18.27 157.58,18.27 158.6,19.29 161.03,19.29 164.18,22.45 v3(164.85,22.45) 165.2,22.09 165.89,22.09 168.4,24.61 170.96,24.61 173.25,26.89 177.56,26.89 178.41,26.04 178.92,26.04 v2(179.43,26.55)
LPT_STB_L: length 35.8
  TOP w0.102: RN15.7 150.98,17.66 v2(150.85,17.79) ; U35.109 v2(179.24,29.85)
  BOTTOM w0.102: v2(179.24,29.85) 177.65,29.85 176.75,28.95 v3(175.21,28.95) 174.84,28.58 172.63,28.58 170.28,26.23 167.39,26.23 166.62,25.47 164.82,25.47 162.12,22.77 159.46,22.77 156.55,19.87 152.77,19.87 150.85,17.95 v2(150.85,17.79)
LPTVCC: length 20.4
  TOP w0.508: v2(165.39,11.88) 165.65,11.88 166.63,10.9 C572.1 167.19,10.12 D26.N ; R567.2 v2(149.45,11.88)
  BOTTOM w0.508: v2(165.39,11.88) v2(164.06,11.88) v2(160,11.88) v2(155.99,11.88) v3(153.67,11.88) v2(151.8,11.88) v2(149.45,11.88)
LRST_L: length 6.8
  TOP w0.102: v1(173.46,11.65) 173.51,11.59 R574.2 C568.1 175.44,11.59 176.68,12.84 176.68,14.65 176.84,14.8 U35.46
M_ACT_A_L: length 60.7
  TOP w0.089: CPU.AU24 127.43,98.19 127.24,98 127.24,93.99 127.19,93.94 127.19,93.49
  TOP w0.216: 127.19,93.49 127.19,83.13 129.28,81.04 129.28,75.04 arc(129.09,74.85) 128.9,75.04 128.9,76.88 arc(128.71,77.07) 128.52,76.88 128.52,74.28 128.63,74.17 128.63,60.28 arc(128.44,60.09) 128.25,60.28 128.25,62.72 arc(128.06,62.91) 127.87,62.72 127.87,56.48 127.03,55.64 127.03,52.36 127.35,52.04 DIMM2.62
M_ACT_B_L: length 73.1
  TOP w0.089: v4(131.47,91.66) 131.74,91.93 131.74,93.71 131.65,94.41 131.65,95.16 131.67,95.17 131.67,96.55 131.39,96.83 131.22,96.83 130.96,97.09 130.96,97.82 CPU.AU28
  GND w0.178: v4(131.47,91.66) 131.28,91.85 130.68,91.85 130.46,91.64 130.46,90.17 131.28,89.36 131.28,83.14 130.76,82.62 130.76,79.97 131.75,78.98 131.75,75.87 133.34,74.28 133.34,73.5 133.08,73.24 132.76,73.24 132.43,72.91 132.43,69.47 arc(132.66,69.24) 132.88,69.47 132.88,72.49 arc(133.11,72.72) 133.34,72.49 133.34,69.02 132.58,68.26 132.58,56.67 131.55,55.64 131.55,54.43 129.21,52.09 129.21,51.46 130.06,50.61 130.06,49.24 129.21,48.39 129.21,47.28 129.78,46.71 129.78,45.75 129.06,45.02 129.06,43.81 127.35,42.1 DIMM1.62
M_ALERT_A_L: length 55
  TOP w0.089: 125.95,95.97 126.18,96.2 126.18,97.26 126.42,97.5 126.42,98.77 CPU.AT23
  TOP w0.102: 125.95,95.97 125.95,93.69 126,93.64 126,82.57 127.38,81.19 127.38,70.46 126.61,69.69 126.61,60.37 125.88,59.64 125.88,56.8 125.73,56.65 125.73,52.56 125.49,52.33 125.49,51.2 124.86,50.57 124.86,49.4 125.65,48.61 DIMM2.208
M_ALERT_B_L: length 63.8
  TOP w0.102: v4(129.53,83.73) 128.59,84.68 CPU.AY25
  GND w0.102: DIMM1.208 125.65,38.5 124.88,39.27 124.88,40.54 125.49,41.15 125.49,42.93 126.31,43.75 126.31,44.36 126.86,44.92 126.86,45.57 126.66,45.77 126.66,46.74 127.19,47.26 127.19,48.47 126.66,48.99 126.66,50.65 127.19,51.17 127.19,52.57 129.88,55.26 129.88,56.48 131.1,57.7 131.1,59.95 130.18,60.88 130.18,66.88 129.15,67.91 129.15,83.35 v4(129.53,83.73)
M_BA_A0: length 59.9
  TOP w0.089: CPU.AY13 117.62,94.16 116.48,93.02 116.48,93.02
  TOP w0.216: DIMM2.81 106.1,53.17 110.61,57.68 110.61,57.7 115.72,62.81 115.72,79.19 arc(115.91,79.38) 116.1,79.19 116.1,73.91 arc(116.29,73.72) 116.48,73.91 116.48,93.02
M_BA_A1: length 62.4
  TOP w0.089: 118.49,94.42 118.49,94.8 118.87,95.18 118.87,96.14 119.1,96.38 119.1,97.06 119.31,97.27 CPU.AV15
  TOP w0.165: 107.36,52.38 107.11,52.12 107.11,51.31 106.26,50.46 106.26,49.2 106.95,48.51 DIMM2.224
  TOP w0.216: 118.49,94.42 118.49,93.94 117.24,92.7 117.24,68.73 arc(117.05,68.54) 116.86,68.73 116.86,69.4 arc(116.67,69.59) 116.48,69.4 116.48,62.49 111.38,57.39 111.38,56.29 108.69,53.6 arc(108.42,53.6) 108.42,53.87 109.12,54.57 arc(109.12,54.84) 108.85,54.84 107.36,53.35 107.36,52.38
M_BA_B0: length 79.7
  TOP w0.089: CPU.AL18 v4(121.73,104.13)
  GND w0.089: v4(121.73,104.13) 122.16,103.71 122.16,103.04 121.72,102.61 121.72,101.08 121.09,100.45 121.09,98.4 121.31,97.92 121.31,97.43 121.06,97.18 121.06,94.1 120.91,93.95 120.91,93.54
  GND w0.178: 120.91,93.54 120.91,91.23 116.71,87.03 116.71,83.28 arc(116.94,83.05) 117.17,83.28 117.17,83.99 arc(117.4,84.22) 117.63,83.99 117.63,62.79 116.92,62.09 arc(116.76,62.02) 116.6,62.09 116.44,62.25 arc(116.12,62.25) 116.12,61.92 116.28,61.76 arc(116.28,61.44) 115.95,61.44 115.79,61.6 arc(115.47,61.6) 115.47,61.28 115.63,61.12 arc(115.63,60.79) 115.31,60.79 115.15,60.95 arc(114.82,60.95) 114.82,60.63 114.98,60.47 arc(114.98,60.15) 114.66,60.15 114.5,60.31 arc(114.18,60.31) 114.18,59.98 114.34,59.82 arc(114.34,59.5) 114.01,59.5 113.85,59.66 arc(113.53,59.66) 113.53,59.34 113.69,59.18 arc(113.76,59.02) 113.69,58.85 108.04,53.21 107.57,53.21 106.79,52.43 106.79,51.45 105.94,50.6 105.94,50.38 105.94,49.7 106.79,48.85 106.79,47.66 105.94,46.81 105.94,45.79 105.26,45.11 105.26,43.33 106.1,42.49 DIMM1.81
M_BA_B1: length 79
  TOP w0.089: CPU.AM18 v4(122.64,103.22)
  GND w0.089: 121.88,92.8 121.88,93.75 121.7,93.92 121.7,95.08 122.18,95.56 122.18,100.61 121.98,100.82 121.98,102.54 v4(122.64,103.22)
  GND w0.178: 121.88,92.8 121.88,90.9 118.54,87.56 118.54,61.15 117.71,60.31 arc(117.54,60.23) 117.37,60.3 117.18,60.49 arc(116.86,60.49) 116.86,60.16 117.05,59.97 arc(117.05,59.65) 116.72,59.65 116.41,59.96 arc(116.09,59.96) 116.09,59.64 116.4,59.33 arc(116.4,59) 116.08,59 115.77,59.31 arc(115.6,59.38) 115.44,59.31 108.67,52.54 108.67,51.61 107.64,50.58 107.64,49.1 108.49,48.25 108.49,47.64 107.64,46.79 107.64,45.57 107.12,45.04 107.12,41.41 107.73,40.79 107.73,39.4 106.95,38.62 DIMM1.224
M_BG_A0: length 59.6
  TOP w0.089: CPU.AW23 126.76,95.97 126.63,95.85 126.63,95.83 126.62,95.83 126.42,95.63 126.42,94.11 126.81,93.71 126.81,90.79
  TOP w0.165: DIMM2.63 126.52,51.78 126.52,53.27
  TOP w0.216: 126.52,53.27 126.52,55.66 127.49,56.63 127.49,63.1 128.14,63.76 128.14,69.15 arc(127.95,69.34) 127.76,69.15 127.76,66.67 arc(127.57,66.48) 127.38,66.67 127.38,69.41 128.14,70.17 128.14,80.5 arc(128.33,80.69) 128.52,80.5 128.52,77.75 arc(128.71,77.56) 128.9,77.75 128.9,80.88 126.81,82.97 126.81,90.79
M_BG_A1: length 61.9
  TOP w0.089: 126.43,90.87 126.43,93.67 126.15,93.96 126.15,95.76 126.4,96.01 126.4,96.58 126.76,96.94 CPU.AV23
  TOP w0.165: 126.13,53.26 126.13,52.41 125.8,52.07 125.8,51.2 126.66,50.34 126.66,48.12 DIMM2.207
  TOP w0.216: 126.43,90.87 126.43,82.81 127.76,81.49 127.76,70.33 127,69.56 127,64.35 arc(127.19,64.16) 127.38,64.35 127.38,65.87 arc(127.57,66.06) 127.76,65.87 127.76,63.91 127.1,63.26 127.1,57 arc(126.91,56.81) 126.72,57 126.72,59.48 arc(126.53,59.67) 126.34,59.48 126.34,56.26 126.12,56.04 126.12,53.27 126.13,53.26
M_BG_B0: length 71.6
  TOP w0.089: CPU.AW28 131.33,96 131,95.66 131,95.23 131.12,95.11 131.12,94.45 131.01,94.34 131.01,92.39 130.69,92.06 130.69,89.58 v4(130.35,89.24)
  GND w0.178: v4(130.35,89.24) 130.82,88.77 130.82,83.36 130.3,82.85 130.3,79.78 131.22,78.86 131.22,76.41 arc(130.99,76.18) 130.76,76.41 130.76,78.52 arc(130.53,78.75) 130.3,78.52 130.3,76.05 130.02,75.77 130.02,74.14 130.94,73.23 130.94,70.64 arc(130.71,70.42) 130.48,70.64 130.48,72.87 arc(130.25,73.1) 130.02,72.87 130.02,68.34 132,66.36 132,56.74 131.09,55.83 131.09,54.61 128.89,52.41 128.89,51.32 129.74,50.47 129.74,49.4 128.89,48.55 128.89,47.28 128.36,46.76 128.36,44 126.5,42.14 DIMM1.63
M_BG_B1: length 70.5
  TOP w0.089: v4(130.2,87.85) 130.93,88.58 130.93,91.8 131.39,92.25 131.39,95.39 CPU.AY28
  GND w0.178: v4(130.2,87.85) 130.36,87.68 130.36,83.62 129.57,82.82 129.57,68.16 130.63,67.09 130.63,62.5 arc(130.86,62.27) 131.09,62.5 131.09,65.79 arc(131.32,66.02) 131.55,65.79 131.55,56.93 130.63,56.02 130.63,55.16 127.51,52.05 127.51,51.29 128.31,50.5 128.31,49.37 127.51,48.58 127.51,47.2 128.04,46.68 128.04,46 127.68,45.64 127.68,44.16 125.81,42.3 125.81,41.38 126.5,40.69 DIMM1.207
M_CKE_A0: length 54.7
  TOP w0.089: CPU.AY24 127.67,93.8 127.63,93.75 127.63,93.4
  TOP w0.165: 127.63,93.4 127.63,83.31 129.72,81.22 129.72,74.74 129.11,74.14 129.11,56.4 arc(128.91,56.19) 128.7,56.4 128.7,59.44 arc(128.5,59.65) 128.3,59.44 128.3,55.54 128.24,55.49 128.24,53.05 129.05,52.24 129.05,51.38 128.56,50.88 128.56,50.34 128.74,50.16 DIMM2.60
M_CKE_A1: length 55.1
  TOP w0.089: CPU.AW24 128.01,96.02 128.01,95.26 128.06,95.21 128.06,93.68 128.03,93.66
  TOP w0.165: 128.03,93.66 128.03,83.48 130.12,81.39 130.12,76.99 arc(130.33,76.79) 130.53,76.99 130.53,77.9 arc(130.73,78.1) 130.93,77.9 130.93,76.67 130.28,76.01 130.28,74.44 129.52,73.68 129.52,55.87 130.42,54.97 130.42,54.65 arc(130.36,54.5) 130.21,54.44 129.83,54.44 arc(129.63,54.24) 129.83,54.04 130.21,54.04 arc(130.36,53.98) 130.42,53.83 130.42,52.7 130.59,52.52 130.59,51.39 129.9,50.7 DIMM2.203
M_CKE_B0: length 64.7
  TOP w0.089: CPU.AY29 132.18,95.38 132.18,94.5 132.47,92.54 132.47,91.46 132.21,90.69
  TOP w0.102: 132.21,90.69 v4(132.21,90.66)
  GND w0.14: DIMM1.60 129.05,42.17 130.08,43.2 130.08,44.58 131.42,45.92 131.42,46.64 130.59,47.46 130.59,48.6 131.48,49.49 131.48,50.42 130.64,51.26 130.64,52.63 132.06,54.04 132.06,55.43 133.09,56.46 133.09,68.05 133.85,68.81 133.85,74.49 132.26,76.08 132.26,82.02 arc(132.01,82.26) 131.77,82.02 131.77,80.28 arc(131.52,80.04) 131.28,80.28 131.28,82.37 131.78,82.87 131.78,89.54 132.21,89.97 v4(132.21,90.66)
M_CKE_B1: length 67.2
  TOP w0.089: v4(133.06,88.54) 132.34,89.26 132.34,90.18 132.8,90.65 132.8,92.54 132.81,92.54 132.48,94.57 132.48,95.15 132.58,95.26 132.58,96.55 132.25,96.89 CPU.AV29
  GND w0.14: DIMM1.203 129.9,40.62 130.77,41.49 130.77,44.06 131.78,45.07 131.78,46.82 130.92,47.69 130.92,48.37 131.78,49.23 131.78,50.6 130.93,51.45 130.93,52.23 132.6,53.89 132.6,55.17 arc(132.85,55.42) 133.09,55.17 133.09,54.42 arc(133.33,54.17) 133.58,54.42 133.58,67.85 134.34,68.61 134.34,74.69 132.75,76.28 132.75,83.11 132.27,83.58 132.27,88.14 132.67,88.54 v4(133.06,88.54)
M_CLK_A_N0: length 60.4
  TOP w0.102: CPU.AV18 122.19,96.91 122.54,96.56 122.54,95.92 122.82,95.65 122.82,94.34 122.4,93.92 121.69,93.92 120.05,92.28 120.05,91.45 120.12,91.38 120.12,91.36
  TOP w0.165: DIMM2.75 116.3,51.27 116.13,51.1 115.86,51.1 115.61,51.35 115.61,52.51 115.89,52.78 115.89,52.8 115.91,52.82
  TOP w0.203: 120.12,91.36 120.12,61.92 119.97,61.77 arc(119.96,61.77) 119.96,61.76 115.96,57.76 arc(115.86,57.51) 115.96,57.26 arc(116.21,57.16) 116.46,57.26 118.94,59.74 arc(119.91,59.74) 119.91,58.77 116.89,55.75 arc(116.85,55.68) 116.83,55.6 116.83,53.83 arc(116.81,53.75) 116.77,53.68 115.91,52.82
M_CLK_A_N1: length 61.7
  TOP w0.102: CPU.AY17 121.27,95.67 121.39,95.79 121.53,95.79 121.64,95.67 121.64,95.17 118.79,92.32 118.79,91.45 118.72,91.38 118.72,91.36
  TOP w0.165: DIMM2.219 116.3,47.47 116.46,47.31 116.87,47.31 117.02,47.46 117.02,48.37 116.49,48.9 115.41,48.9 115.4,48.89 115.37,48.89
  TOP w0.203: 118.72,91.36 118.72,62.64 113.14,57.06 arc(113.09,56.99) 113.08,56.91 113.08,51.55 arc(112.72,51.2) 112.37,51.55 112.37,51.58 arc(111.68,52.27) 111,51.58 111,50.84 112.94,48.89 115.37,48.89
M_CLK_A_P0: length 60.4
  TOP w0.102: CPU.AW18 122.34,96.21 122.34,95.83 122.61,95.56 122.61,94.42 122.32,94.13 121.61,94.13 119.85,92.36 119.85,91.45 119.79,91.38 119.79,91.36
  TOP w0.165: DIMM2.74 117.02,50.16 116.38,50.81 115.74,50.81 115.32,51.22 115.32,52.63 115.59,52.91 115.59,52.95 115.66,53.01 115.66,53.04 115.67,53.05
  TOP w0.203: 119.79,91.36 119.79,62.14 arc(119.77,62.06) 119.73,62 115.73,58 arc(115.53,57.51) 115.73,57.03 115.73,57.03 arc(116.21,56.83) 116.7,57.03 119.17,59.5 arc(119.68,59.5) 119.68,59 116.5,55.82 116.5,53.88 115.67,53.05
M_CLK_A_P1: length 61.7
  TOP w0.102: CPU.AW17 121.84,95.79 121.84,95.09 118.99,92.24 118.99,91.45 119.05,91.38 119.05,91.36
  TOP w0.165: DIMM2.218 117.15,47.19 117.31,47.34 117.31,48.5 116.61,49.19 115.5,49.19 115.5,49.2 115.41,49.2 115.39,49.22 115.37,49.22
  TOP w0.203: 119.05,91.36 119.05,62.51 113.41,56.86 113.41,51.55 arc(112.72,50.87) 112.04,51.55 112.04,51.58 arc(111.68,51.94) 111.33,51.58 111.33,50.97 113.08,49.22 115.37,49.22
M_CLK_B_N0: length 81.3
  TOP w0.102: v4(125.39,103.22) CPU.AM21
  GND w0.102: 125.01,92.8 125.01,92.83 124.95,92.89 124.95,94.72 125.78,95.55 125.78,97.23 124.92,98.1 124.92,98.93 126.01,100.02 126.01,101.19 124.89,102.3 124.89,103.12 125.04,103.27 125.34,103.27 v4(125.39,103.22)
  GND w0.178: 125.01,92.8 125.01,89.76 122.44,87.19 122.44,82.46 arc(122.28,82.06) 121.88,81.9 arc(121.53,81.54) 121.88,81.19 121.98,81.19 arc(122.31,81.06) 122.44,80.73 122.44,80.4 arc(122.28,80.01) 121.88,79.84 arc(121.53,79.49) 121.88,79.13 121.98,79.13 arc(122.31,79) 122.44,78.67 122.44,78.34 arc(122.28,77.95) 121.88,77.79 arc(121.53,77.43) 121.88,77.07 121.98,77.07 arc(122.31,76.94) 122.44,76.62 122.44,76.29 arc(122.28,75.89) 121.88,75.73 arc(121.53,75.37) 121.88,75.02 121.98,75.02 arc(122.31,74.88) 122.44,74.56 122.44,74.23 arc(122.28,73.83) 121.88,73.67 arc(121.53,73.32) 121.88,72.96 121.98,72.96 arc(122.31,72.83) 122.44,72.5 122.44,72.17 arc(122.28,71.78) 121.88,71.61 arc(121.53,71.26) 121.88,70.9 121.98,70.9 arc(122.31,70.77) 122.44,70.45 122.44,70.11 arc(122.28,69.72) 121.88,69.56 arc(121.63,69.45) 121.53,69.2 121.53,59.21 118.9,56.58 118.9,55.19 117.04,53.33 115.04,53.33 114.75,53.03 113.45,51.73 113.45,41.75 114.15,41.05 114.7,41.05 114.93,41.27 115.88,41.27 116.16,40.99 116.36,40.99 116.56,41.2 116.56,41.6 DIMM1.75
M_CLK_B_N1: length 78.9
  TOP w0.102: v4(124.45,100.48) 124.91,100.93 CPU.AP21
  GND w0.102: v4(124.45,100.48) 124.73,100.2 124.73,99.94 124.1,99.32 124.1,97.99 123.73,97.62 123.73,92.89 123.67,92.83 123.67,92.8
  GND w0.178: 123.67,92.8 123.67,90.36 120.16,86.84 120.16,86.01 arc(120.35,85.54) 120.83,85.34 arc(121.03,85.26) 121.11,85.06 121.11,84.79 arc(121.06,84.68) 120.95,84.63 120.83,84.63 arc(120.35,84.43) 120.16,83.96 120.16,59.74 116.83,56.41 116.83,55.17 116.35,54.69 114.43,54.69 112.11,52.37 112.11,45.27 111.23,44.38 111.23,41.42 111.84,40.81 111.84,38.79 112.25,38.37 113.26,38.37 114.05,39.17 116.66,39.17 116.99,38.83 116.99,37.64 116.78,37.43 116.46,37.43 116.3,37.59 DIMM1.219
M_CLK_B_P0: length 81.4
  TOP w0.102: v4(124.47,103.22) CPU.AM20
  GND w0.102: v4(124.47,103.22) 124.69,103 124.69,102.22 125.81,101.1 125.81,100.1 124.71,99.01 124.71,98.01 125.58,97.15 125.58,95.63 124.75,94.8 124.75,92.89 124.69,92.83 124.69,92.8
  GND w0.178: 124.69,92.8 124.69,89.89 122.12,87.32 122.12,82.46 arc(122.05,82.29) 121.88,82.22 arc(121.21,81.54) 121.88,80.87 121.98,80.87 arc(122.08,80.83) 122.12,80.73 122.12,80.4 arc(122.05,80.23) 121.88,80.16 arc(121.21,79.49) 121.88,78.81 121.98,78.81 arc(122.08,78.77) 122.12,78.67 122.12,78.34 arc(122.05,78.17) 121.88,78.1 arc(121.21,77.43) 121.88,76.76 121.98,76.76 arc(122.08,76.72) 122.12,76.62 122.12,76.29 arc(122.05,76.12) 121.88,76.05 arc(121.21,75.37) 121.88,74.7 121.98,74.7 arc(122.08,74.66) 122.12,74.56 122.12,74.23 arc(122.05,74.06) 121.88,73.99 arc(121.21,73.32) 121.88,72.64 121.98,72.64 arc(122.08,72.6) 122.12,72.5 122.12,72.17 arc(122.05,72) 121.88,71.93 arc(121.21,71.26) 121.88,70.58 121.98,70.58 arc(122.08,70.54) 122.12,70.45 122.12,70.11 arc(122.05,69.94) 121.88,69.87 arc(121.41,69.68) 121.21,69.2 121.21,59.34 118.58,56.72 118.58,55.32 116.91,53.64 114.91,53.64 114.37,53.1 113.13,51.86 113.13,41.62 114.02,40.73 114.83,40.73 115.06,40.96 115.75,40.96 116.02,40.68 116.74,40.68 DIMM1.74
M_CLK_B_P1: length 78.9
  TOP w0.102: CPU.AP22 125.82,100.93 v4(125.36,100.48)
  GND w0.102: 123.99,92.8 123.99,92.83 123.93,92.89 123.93,97.54 124.31,97.91 124.31,99.23 124.93,99.85 124.93,100.04 v4(125.36,100.48)
  GND w0.178: 123.99,92.8 123.99,90.23 120.47,86.71 120.47,86.01 arc(120.58,85.76) 120.83,85.66 arc(121.25,85.48) 121.43,85.06 121.43,84.79 arc(121.29,84.45) 120.95,84.31 120.83,84.31 arc(120.58,84.21) 120.47,83.96 120.47,59.61 117.15,56.28 117.15,55.03 116.48,54.37 114.57,54.37 112.43,52.24 112.43,45.14 111.54,44.25 111.54,41.55 112.15,40.94 112.15,38.92 112.38,38.69 113.13,38.69 113.92,39.49 116.79,39.49 117.31,38.96 117.31,37.51 117.11,37.31 117.11,36.51 DIMM1.218
M_CS_A_L0: length 56
  TOP w0.089: CPU.AW12 116.36,96.02 116.36,95.31 115.56,94.51
  TOP w0.165: DIMM2.84 103.4,50.32 103.4,53.42 105.16,55.19 arc(105.45,55.19) 105.45,54.9 104.53,53.98 arc(104.53,53.69) 104.82,53.69 111.44,60.32 111.44,61.52 114.53,64.6 114.53,83.19 115.29,83.96 115.29,94.23 115.56,94.51
M_CS_A_L1: length 57.1
  TOP w0.089: CPU.AU11 115.11,98.19
  TOP w0.165: 115.11,98.19 113.88,96.95 113.88,95.98 113.55,95.65 113.55,91.62 arc(113.49,91.49) 113.36,91.43 arc(113.23,91.38) 113.17,91.24 113.17,91.21 arc(113.23,91.08) 113.36,91.03 arc(113.49,90.97) 113.55,90.84 113.55,90.81 arc(113.49,90.67) 113.36,90.62 arc(113.23,90.56) 113.17,90.43 113.17,90.4 arc(113.23,90.27) 113.36,90.21 arc(113.49,90.16) 113.55,90.03 113.55,89.99 arc(113.49,89.86) 113.36,89.81 arc(113.23,89.75) 113.17,89.62 113.17,89.59 arc(113.23,89.45) 113.36,89.4 arc(113.49,89.35) 113.55,89.22 113.55,89.08 113.45,88.99 113.36,88.99 arc(113.23,88.94) 113.17,88.81 113.17,88.77 arc(113.23,88.64) 113.36,88.59 arc(113.49,88.53) 113.55,88.4 113.55,88.37 arc(113.49,88.24) 113.36,88.18 arc(113.23,88.13) 113.17,87.99 113.17,87.96 arc(113.23,87.83) 113.36,87.77 arc(113.49,87.72) 113.55,87.59 113.55,87.56 arc(113.49,87.42) 113.36,87.37 arc(113.23,87.31) 113.17,87.18 113.17,87.15 arc(113.23,87.02) 113.36,86.96 arc(113.49,86.91) 113.55,86.77 113.55,86.74 arc(113.49,86.61) 113.36,86.56 arc(113.23,86.5) 113.17,86.37 113.17,86.34 arc(113.23,86.2) 113.36,86.15 arc(113.49,86.09) 113.55,85.96 113.55,85.93 arc(113.49,85.8) 113.36,85.74 arc(113.23,85.69) 113.17,85.56 113.17,85.52 arc(113.23,85.39) 113.36,85.34 arc(113.49,85.28) 113.55,85.15 113.55,84.66 112.8,83.91 112.8,65.32 99.3,51.83 DIMM2.89
M_CS_B_L0: length 71.2
  TOP w0.089: v4(120.79,101.39) 121.25,100.93 CPU.AP17
  GND w0.089: v4(120.79,101.39) 120.37,100.96 120.37,98.34 119.72,96.56 119.72,95.3 119.34,94.91 119.34,94.14
  GND w0.14: DIMM1.84 103.37,40.45 103.37,42.36 102.59,43.14 102.59,44.87 102.88,45.15 102.88,46.68 103.7,47.49 103.7,48.89 102.85,49.74 102.85,50.4 103.74,51.29 103.74,52.18 104.5,52.94 104.77,52.94 116.18,64.36 116.18,81.71 115.29,82.6 115.29,87.69 119.34,91.74 119.34,94.14
M_CS_B_L1: length 73.4
  TOP w0.089: CPU.AN15 v4(118.99,102.3)
  GND w0.089: v4(118.99,102.3) 118.45,101.76 118.45,99 117.64,98.2 117.64,96.22 117.13,95.71 117.13,94.81
  GND w0.14: 117.13,94.81 117.13,92.42 113.23,88.53 113.23,81.22 113.86,80.6 113.86,74.56 113.85,74.55 113.85,71.55 113.23,70.92 113.23,64.69 arc(112.99,64.45) 112.74,64.69 112.74,65.48 arc(112.5,65.72) 112.26,65.48 112.26,63.46 101.29,52.5 100.75,52.5 100.27,52.02 100.27,51.26 99.49,50.47 99.49,49.38 100.26,48.6 100.26,47.46 99.49,46.69 99.49,45.22 99.3,45.04 DIMM1.89
M_DATA_A0: length 97.4
  TOP w0.089: 146.76,111.54 146.09,111.54 143.71,109.16 CPU.AE40
  TOP w0.165: 146.76,111.54 155.69,111.54 164.95,102.29 164.95,101.51 178.85,87.6 178.85,78.11 arc(178.54,77.79) 178.22,78.11 178.22,83.55 arc(177.9,83.86) 177.58,83.55 177.58,70.23 175.79,68.43 DIMM2.5
M_DATA_A1: length 101.1
  TOP w0.089: CPU.AE37 139.94,108.78 140.88,108.78 141.07,108.59 141.71,108.59 141.95,108.83 142.52,108.83 142.62,108.92 143.96,108.92 145.94,110.91 146.76,110.91
  TOP w0.165: DIMM2.150 175.09,46.51 175.09,48.84 175.68,49.43 175.68,50.75 174.91,51.52 174.91,68.45 176.95,70.49 176.95,84.92 arc(177.27,85.24) 177.58,84.92 177.58,84.82 arc(177.9,84.5) 178.22,84.82 178.22,85.41 arc(178.2,85.53) 178.13,85.64 175.18,88.59 arc(175.18,89.04) 175.62,89.04 177.36,87.3 arc(177.81,87.3) 177.81,87.75 164.31,101.25 164.31,102.03 155.43,110.91 146.76,110.91
M_DATA_A2: length 99.2
  TOP w0.089: 146.69,108.07 145.7,108.07 144.72,107.09 142.6,107.09 142.5,107 140.81,107 CPU.AG38
  TOP w0.165: 146.69,108.07 154.26,108.07 161.48,100.85 161.48,98.28 173.85,85.9 arc(173.85,85.45) 173.4,85.45 167.95,90.91 arc(167.5,90.91) 167.5,90.46 174.12,83.84 174.12,71.66 170.68,68.23 170.68,53.01 170.01,52.34 170.01,50.33 DIMM2.12
M_DATA_A3: length 100.2
  TOP w0.089: 146.69,107.44 145.56,107.44 144.97,106.84 142.76,106.84 142.67,106.76 140.65,106.76 140.52,106.88 140.01,106.88 CPU.AG37
  TOP w0.165: DIMM2.157 168.99,50.68 169.67,51.36 169.67,52.94 170.05,53.32 170.05,68.49 173.48,71.93 173.48,83.58 160.99,96.07 arc(160.99,96.52) 161.44,96.52 166.52,91.44 arc(166.97,91.44) 166.97,91.89 160.85,98.01 160.85,100.59 153.99,107.44 146.69,107.44
M_DATA_A4: length 98.5
  TOP w0.089: CPU.AE39 141.97,109.74 142.64,109.74 142.73,109.65 143.23,109.65 146.39,112.81 146.76,112.81
  TOP w0.165: 146.76,112.81 155.69,112.81 156.22,112.81 166.23,102.8 166.23,102.02 180.12,88.13 180.12,69.12 arc(179.81,68.8) 179.49,69.12 179.49,73.41 arc(179.17,73.73) 178.85,73.41 178.85,69.7 177.49,68.34 DIMM2.3
M_DATA_A5: length 100
  TOP w0.089: 146.76,112.18 146.24,112.18 143.47,109.4 142.63,109.4 142.53,109.5 142.11,109.5 141.9,109.28 141.9,109.14 141.58,108.83 141.2,108.83 140.86,109.16 CPU.AE38
  TOP w0.165: 146.76,112.18 155.96,112.18 165.58,102.55 165.58,101.77 179.49,87.87 179.49,74.78 arc(179.17,74.47) 178.85,74.78 178.85,76.76 arc(178.54,77.08) 178.22,76.76 178.22,69.96 176.65,68.4 176.65,51.43 177.45,50.63 177.45,49.46 176.64,48.65 DIMM2.148
M_DATA_A6: length 97.9
  TOP w0.089: 146.68,109.34 145.98,109.34 144.21,107.58 142.62,107.58 142.49,107.71 142.15,107.71 141.78,107.33 CPU.AG39
  TOP w0.165: 146.68,109.34 154.78,109.34 162.75,101.38 162.75,100.6 173.22,90.12 arc(173.22,89.68) 172.77,89.68 168.27,94.18 arc(167.82,94.18) 167.82,93.73 175.39,86.16 175.39,71.14 171.95,67.7 171.95,52.35 171.7,52.1 171.7,50.32 DIMM2.10
