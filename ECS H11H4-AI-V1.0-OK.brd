# Allegro board ECS H11H4-AI-V1.0-OK.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_DATA_B27: length 82.4
  TOP w0.089: CPU.AR28 131.33,99.99 v4(130.91,99.56)
  GND w0.089: v4(130.91,99.56) 131.35,99.12 131.35,98.46 131.59,98.21 131.88,98.21 132.19,97.91 132.19,97.43 134.72,94.9 134.88,94.58 135.47,93.82 136.44,92.43 136.89,91.03 138.95,88.29 138.95,88.1 139.45,87.6
  GND w0.14: 139.45,87.6 142.04,85.02 142.04,77.57 142.44,77.16 142.44,57.65 arc(142.76,57.33) 143.08,57.65 143.08,62.22 arc(143.4,62.53) 143.71,62.22 143.71,54.26 142.46,53.02 142.46,51.29 143.31,50.44 143.31,49.28 144.16,48.43 144.16,47.65 143.31,46.8 143.31,46.08 142.67,45.44 142.67,44.22 141.06,42.6 141.06,41.61 140.28,40.83 140.28,39.74 140.95,39.07 DIMM1.190
M_DATA_B28: length 85.8
  TOP w0.089: CPU.AL29 v4(132.7,104.13)
  GND w0.089: 140.05,96.92 139.72,97.1 138.48,97.48 138.33,97.52 137.53,98.11 137.38,98.16 135.34,98.16 135.11,98.4 134.95,98.75 134.95,98.75 134.62,99.08 134.62,99.08 134.31,99.19 134.11,99.39 134.11,102.1 133.62,102.73 133.58,102.77 133.45,102.77 133.16,103.06 133.16,103.36 132.7,103.82 v4(132.7,104.13)
  GND w0.14: 140.05,96.92 142.12,94.85 142.12,92.93 149.17,85.87 149.17,77.11 arc(149.26,76.92) 149.45,76.83 arc(149.65,76.75) 149.73,76.55 149.73,76.48 arc(149.65,76.28) 149.45,76.2 arc(149.26,76.12) 149.17,75.92 149.17,75.84 arc(149.26,75.65) 149.45,75.56 arc(149.65,75.48) 149.73,75.28 149.73,75.21 arc(149.65,75.01) 149.45,74.93 arc(149.26,74.85) 149.17,74.65 149.17,74.57 arc(149.26,74.38) 149.45,74.29 arc(149.65,74.21) 149.73,74.01 149.73,73.35 arc(150.05,73.03) 150.37,73.35 150.37,76.69 arc(150.69,77.01) 151,76.69 151,53.62 149.63,52.25 149.63,51.45 150.48,50.6 150.48,49.34 151.33,48.49 151.33,47.49 150.48,46.64 150.48,45.98 150.79,45.67 150.79,43.34 149.63,42.18 149.63,40.45 DIMM1.36
M_DATA_B29: length 86.4
  TOP w0.089: CPU.AL28 v4(131.79,104.13)
  GND w0.089: 139.6,96.42 138.63,96.97 137.26,97.33 137.04,97.33 136.5,97.87 135.28,97.87 134.92,98.23 134.92,98.23 134.75,98.61 134.47,98.89 134.15,99 133.87,99.28 133.87,101.85 132.93,102.79 132.52,102.79 132.21,103.1 132.21,103.4 131.79,103.83 v4(131.79,104.13)
  GND w0.14: DIMM1.181 148.78,38.25 148.78,40.8 149.26,41.28 149.26,42.38 150.11,43.23 150.11,46.79 150.96,47.64 150.96,48.32 150.11,49.17 150.11,50.45 149.26,51.3 149.26,51.92 149.26,52.84 150.37,53.94 150.37,71.84 arc(150.05,72.15) 149.73,71.84 149.73,69.23 arc(149.42,68.91) 149.1,69.23 149.1,69.86 arc(149.02,70.06) 148.82,70.14 arc(148.62,70.22) 148.54,70.42 148.54,70.5 arc(148.62,70.7) 148.82,70.78 arc(149.02,70.86) 149.1,71.06 149.1,71.13 arc(149.02,71.33) 148.82,71.41 arc(148.62,71.49) 148.54,71.69 148.54,71.77 arc(148.62,71.97) 148.82,72.05 arc(149.02,72.13) 149.1,72.33 149.1,72.4 arc(149.02,72.6) 148.82,72.68 arc(148.62,72.76) 148.54,72.96 148.54,85.61 141.46,92.69 141.46,94.56 139.6,96.42
M_DATA_B30: length 83
  TOP w0.089: v4(131.81,100.48) 132.25,100.91 CPU.AP29
  GND w0.089: v4(131.81,100.48) 131.82,100.48 132.43,99.86 132.7,99.35 132.7,98.57 133.17,98.1 133.17,97.56 133.38,97.34 133.98,97.09 134.66,96.42 135.45,96.42 135.92,95.95 135.92,95.47 138.59,92.8 138.59,92.14
  GND w0.14: DIMM1.43 143.83,41.87 145.45,43.49 145.45,45.34 145.38,45.41 145.38,46.64 146.23,47.49 146.23,48.9 145.38,49.75 145.38,50.62 144.53,51.47 144.53,52.38 145.68,53.53 145.68,83.04 arc(145.36,83.36) 145.05,83.04 145.05,76.34 arc(144.73,76.02) 144.41,76.34 144.41,85.71 138.59,91.54 138.59,92.14
M_DATA_B31: length 83.7
  TOP w0.089: CPU.AP28 131.33,100.91 v4(130.91,100.48)
  GND w0.089: 138.39,90.56 138.19,91.04 138.06,91.35 137.87,91.78 136.96,93.67 135.52,95.11 135.52,95.88 135.27,96.13 134.47,96.13 133.72,96.87 133.26,97.09 132.86,97.49 132.86,98.04 132.46,98.44 132.46,99.12 132.24,99.33 132.24,99.74 131.96,100.02 131.37,100.02 v4(130.91,100.48)
  GND w0.14: DIMM1.188 142.65,39.12 143.49,39.97 143.49,40.66 142.69,41.46 142.69,42.07 144.04,43.43 144.04,44.98 145.01,45.96 145.01,46.82 145.86,47.67 145.86,48.75 145.01,49.6 145.01,50.44 144.16,51.29 144.16,52.92 145.05,53.8 145.05,75.07 arc(144.73,75.39) 144.41,75.07 144.41,71.05 arc(144.09,70.73) 143.78,71.05 143.78,85.18 138.39,90.56
M_DATA_B32: length 78
  TOP w0.089: CPU.AR12 v4(116.24,100.48)
  GND w0.089: 114.05,94.94 114.05,95.63 114.71,96.3 114.71,97.1 115.67,98.06 115.67,99.63 116.24,100.2 v4(116.24,100.48)
  GND w0.14: DIMM1.97 92.5,42.06 93.89,43.44 94.84,43.44 96.09,44.68 96.09,46.68 96.94,47.53 96.94,48.92 96.09,49.77 96.09,50.45 96.94,51.3 96.94,52.39 109.18,64.63 109.18,68.05 arc(108.86,68.37) 108.54,68.05 108.54,65.51 arc(108.23,65.19) 107.91,65.51 107.91,76.27 109.57,77.93 109.57,80.85 110.84,82.12 110.84,89.52 114.05,92.73 114.05,94.94
M_DATA_B33: length 77.7
  TOP w0.089: CPU.AP12 v4(116.24,101.39)
  GND w0.089: v4(116.24,101.39) 116.24,101.08 115.8,100.63 115.8,100.3 115.25,99.75 115.25,98.14 114.36,97.25 114.36,96.46 113.37,95.47 113.37,94.86
  GND w0.14: DIMM1.242 91.65,38.81 92.49,39.65 92.49,40.79 91.73,41.56 91.73,42.25 94.89,45.41 95.13,45.41 95.72,45.99 95.72,46.83 96.57,47.68 96.57,48.58 95.72,49.43 95.72,50.63 96.57,51.48 96.57,52.92 107.78,64.13 107.78,64.58 107.27,65.09 107.27,76.53 108.93,78.2 108.93,81.12 110.2,82.39 110.2,89.78 113.37,92.95 113.37,94.86
M_DATA_B34: length 83.3
  TOP w0.089: CPU.AL13 v4(117.16,104.13)
  GND w0.089: 110.42,94.58 110.42,95.04 111.26,95.88 111.26,96.46 112,97.21 112.38,97.21 112.68,97.51 112.68,97.91 113.82,99.05 113.82,102.32 115.19,103.7 117.01,103.7 117.16,103.85 v4(117.16,104.13)
  GND w0.14: DIMM1.104 86.74,40.45 86.74,42.99 89.41,45.66 90.27,45.66 90.84,46.23 90.84,46.87 91.54,47.57 91.54,49.02 90.99,49.57 90.99,50.44 91.84,51.29 91.84,52.18 104.41,64.75 104.41,64.79 104.45,64.83 104.45,72.51 104.45,72.51 104.45,77.59 104.45,77.59 104.45,77.7 106.12,79.36 106.12,89.49 arc(106.43,89.81) 106.75,89.49 106.75,88.27 arc(107.07,87.95) 107.39,88.27 107.39,91.03 110.42,94.07 110.42,94.58
M_DATA_B35: length 83.1
  TOP w0.089: CPU.AL12 v4(116.24,104.13)
  GND w0.089: v4(116.24,104.13) 115.81,104.56 114.97,104.56 114.78,104.38 114.78,103.94 113.56,102.72 113.56,99.24 112.48,98.17 112.02,98.17 111.77,97.91 111.77,97.56 110.42,96.21 110.42,95.6 109.79,94.97 109.79,94.53
  GND w0.14: DIMM1.249 86.13,38.07 86.46,38.4 86.46,38.96 85.71,39.71 85.71,40.61 86.37,41.28 86.37,43.35 89.07,46.04 89.07,46.68 89.89,47.5 89.89,48.52 89.13,49.28 89.13,50.42 89.89,51.19 89.89,52.11 90.55,52.77 91.54,52.77 103.78,65.02 103.78,65.05 103.82,65.09 103.82,72.25 103.82,77.96 105.48,79.63 105.48,90.05 109.79,94.36 109.79,94.53
M_DATA_B36: length 79.3
  TOP w0.089: CPU.AR13 v4(117.16,99.56)
  GND w0.089: 115.36,94.75 115.36,95.56 116.66,96.86 116.66,98.56 v4(117.16,99.56)
  GND w0.14: DIMM1.95 94.73,41.87 96.97,44.11 96.97,45.06 97.79,45.87 97.79,46.68 98.64,47.53 98.64,48.82 97.79,49.67 97.79,50.45 98.64,51.3 98.64,52.18 111.13,64.67 111.13,68.02 112.11,69 112.11,71.39 112.62,71.9 112.62,79.76 arc(112.3,80.08) 111.98,79.76 111.98,75.76 arc(111.66,75.44) 111.35,75.76 111.35,80.19 112.11,80.95 112.11,88.99 115.36,92.25 115.36,94.75
M_DATA_B37: length 80.5
  TOP w0.089: CPU.AP13 v4(117.16,100.48)
  GND w0.089: 114.71,94.84 114.71,95.55 115.56,96.4 116.16,97.68 116.16,98.6 116.73,99.47 116.73,99.72 v4(117.16,100.48)
  GND w0.14: DIMM1.240 93.35,38.53 94.27,39.45 94.27,40.6 93.4,41.47 93.4,42 94.26,42.87 95.1,42.87 96.56,44.33 96.56,45.18 97.42,46.04 97.42,46.83 98.27,47.68 98.27,48.48 97.42,49.33 97.42,50.62 98.27,51.47 98.27,52.71 109.81,64.25 109.81,75.51 arc(109.5,75.82) 109.18,75.51 109.18,74.62 arc(108.86,74.3) 108.54,74.62 108.54,76.01 110.2,77.67 110.2,80.59 111.47,81.86 111.47,89.26 114.71,92.5 114.71,94.84
M_DATA_B38: length 82.2
  TOP w0.089: CPU.AM13 v4(117.16,103.22)
  GND w0.089: 111.69,94.74 111.69,95.22 113.39,96.92 113.39,97.61 114.41,98.62 114.41,101.14 115.14,101.88 115.51,101.88 115.76,102.13 115.76,102.42 116.1,102.76 116.7,102.76 v4(117.16,103.22)
  GND w0.14: 111.69,94.74 111.69,93.54 108.66,90.51 108.66,83.35 arc(108.34,83.03) 108.02,83.35 108.02,85.1 arc(107.7,85.42) 107.39,85.1 107.39,78.84 105.72,77.18 105.72,77.06 105.72,77.06 105.72,73.04 105.72,73.04 105.72,64.3 105.68,64.26 105.68,64.23 93.54,52.08 93.54,51.32 92.69,50.47 92.69,49.62 93.54,48.77 93.54,47.51 92.69,46.64 92.69,45.73 91.92,44.96 91.22,44.96 88.44,42.18 88.44,40.45 DIMM1.102
M_DATA_B39: length 82
  TOP w0.089: CPU.AM12 v4(116.24,103.22)
  GND w0.089: 111.06,94.43 111.06,95.06 113.04,97.04 113.04,97.78 114.07,98.82 114.07,101.66 115.12,102.7 115.42,102.7 115.93,103.22 v4(116.24,103.22)
  GND w0.14: 111.06,94.43 111.06,93.81 108.02,90.77 108.02,86.37 arc(107.7,86.06) 107.39,86.37 107.39,86.96 arc(107.07,87.28) 106.75,86.96 106.75,79.1 105.09,77.44 105.09,77.33 105.09,64.56 105.05,64.52 105.05,64.49 93.17,52.61 93.17,51.47 92.32,50.62 92.32,49.27 93.17,48.42 93.17,47.66 92.32,46.81 92.32,46.08 91.77,45.54 90.91,45.54 88.07,42.7 88.07,41.33 87.41,40.66 DIMM1.247
M_DATA_B40: length 82.9
  TOP w0.089: CPU.AP9 v4(112.22,101.39)
  GND w0.089: v4(112.22,101.39) 111.74,100.91 111.74,100.29 111.43,99.99 111.16,99.99 110.8,99.63 110.8,99.13 110.27,98.6 110.27,98.19 108.18,96.1 107.94,96.1 107.68,95.84 107.68,95.45
  GND w0.14: DIMM1.108 83.34,40.45 83.34,42.23 84.05,42.94 84.05,46.74 84.87,47.57 84.87,48.58 84.19,49.27 84.19,50.44 85.04,51.29 85.04,52.3 85.84,53.1 87.33,53.1 98,63.78 arc(98.45,63.78) 98.45,63.33 96.75,61.63 arc(96.75,61.18) 97.2,61.18 101.91,65.9 101.91,71.46 101.91,71.46 101.91,78.64 101.91,78.64 101.91,78.75 103.47,80.31 103.47,90.77 105.5,92.79 107.68,94.96 107.68,95.45
M_DATA_B41: length 81.7
  TOP w0.089: CPU.AR9 v4(111.3,100.48)
  GND w0.089: v4(111.3,100.48) 111.3,100.42 110.45,99.57 110.45,99.21 109.94,98.7 109.94,98.5 107.04,95.6 107.04,95.5
  GND w0.14: DIMM1.253 82.31,40.69 82.97,41.36 82.97,44.9 82.27,45.6 82.27,46.68 83.16,47.57 83.16,48.65 83.82,49.31 83.82,50.63 84.67,51.48 84.67,52.84 85.58,53.74 87.05,53.74 99.82,66.51 arc(100.27,66.51) 100.27,66.06 99.34,65.13 arc(99.34,64.69) 99.79,64.69 101.28,66.17 101.28,71.2 101.28,79.02 102.7,80.44 102.7,90.89 103.3,91.5 103.42,91.61 105.05,93.24 107.04,95.24 107.04,95.5
M_DATA_B42: length 81.4
  TOP w0.089: CPU.AP7 v4(109.47,101.39)
  GND w0.089: 105.85,98.03 106.31,98.49 106.31,98.83 106.59,99.11 106.87,99.11 108.04,100.28 108.04,100.72 108.25,100.92 109.01,100.92 v4(109.47,101.39)
  GND w0.14: DIMM1.115 77.21,45.22 77.39,45.41 77.39,46.64 78.24,47.49 78.24,48.28 79.09,49.13 79.09,50.44 79.94,51.29 79.94,52.21 80.83,53.1 80.83,54.33 89.26,62.76 91.14,62.76 93.12,64.74 93.12,65.19 92.92,65.4 arc(92.82,65.62) 92.92,65.84 92.93,65.85 arc(93.14,65.94) 93.36,65.85 93.57,65.65 arc(93.77,65.56) 93.98,65.65 94,65.66 arc(94.09,65.89) 94,66.11 93.84,66.27 arc(93.76,66.46) 93.84,66.65 93.87,66.69 arc(94.1,66.78) 94.32,66.69 94.45,66.55 arc(94.68,66.46) 94.9,66.55 94.92,66.58 arc(95.01,66.78) 94.92,66.98 94.72,67.18 arc(94.63,67.41) 94.72,67.63 94.74,67.65 arc(94.95,67.73) 95.16,67.65 95.34,67.47 arc(95.56,67.38) 95.78,67.47 95.8,67.49 arc(95.89,67.69) 95.8,67.9 95.6,68.11 arc(95.5,68.33) 95.6,68.55 95.6,68.55 arc(95.82,68.64) 96.05,68.55 96.25,68.35 arc(96.44,68.27) 96.64,68.35 96.67,68.38 arc(96.76,68.61) 96.67,68.83 96.53,68.97 arc(96.44,69.19) 96.53,69.42 96.55,69.44 arc(96.76,69.52) 96.96,69.44 97.16,69.23 97.61,69.23 98.46,70.08 98.46,80.19 99.78,81.51 99.78,92.27 103.97,96.46 104.28,96.46 105.85,98.03
M_DATA_B43: length 80.6
  TOP w0.089: CPU.AP6 v4(108.56,101.39)
  GND w0.089: 105.54,98.62 107.2,100.28 107.2,100.6 107.98,101.39 v4(108.56,101.39)
  GND w0.14: DIMM1.260 76.36,38.77 75.69,39.43 75.69,40.88 76.37,41.56 76.37,44.9 77.02,45.56 77.02,46.87 77.45,47.29 77.48,47.29 77.87,47.68 77.87,48.44 78.72,49.29 78.72,50.63 79.57,51.48 79.57,51.89 79.57,52.52 80.19,53.14 80.19,54.72 89.36,63.89 90.46,63.89 91.09,64.52 91.09,65.62 97.82,72.35 97.82,80.45 99.14,81.77 99.14,92.53 103.74,97.12 104.04,97.12 105.54,98.62
M_DATA_B44: length 83.5
  TOP w0.089: CPU.AP10 v4(113.13,101.39)
  GND w0.089: 109.16,95.3 109.16,95.75 110.88,97.47 110.88,97.62 111.73,98.47 111.73,98.86 112.7,99.84 112.7,100.96 v4(113.13,101.39)
  GND w0.14: 109.16,95.3 109.16,94.65 106.41,91.88 104.85,90.31 104.85,79.89 103.18,78.23 103.18,78.12 103.18,78.12 103.18,71.99 103.18,71.99 103.18,65.35 91.8,53.97 arc(91.35,53.97) 91.35,54.42 93.79,56.86 arc(93.79,57.31) 93.34,57.31 88.27,52.23 88.27,51.4 87.5,50.64 87.5,49.4 88.19,48.71 88.19,47.54 87.45,46.81 87.45,45.83 85.04,43.41 85.04,40.45 DIMM1.106
M_DATA_B45: length 82.6
  TOP w0.089: CPU.AR10 v4(112.22,100.48)
  GND w0.089: 108.53,95.76 110.6,97.84 110.6,98.52 111.18,99.1 111.45,99.1 112.22,99.86 v4(112.22,100.48)
  GND w0.14: 108.53,95.76 108.53,94.91 104.16,90.55 104.16,80.11 102.55,78.49 102.55,71.72 102.55,65.62 95.26,58.33 arc(94.81,58.33) 94.81,58.78 96.29,60.26 arc(96.29,60.71) 95.84,60.71 87.61,52.47 87.02,52.47 86.59,52.04 86.59,51.38 85.7,50.49 85.7,49.47 86.46,48.71 86.46,47.5 85.7,46.74 85.7,46.04 84.67,45.02 84.67,41.31 84.01,40.64 DIMM1.251
M_DATA_B46: length 80.2
  TOP w0.089: CPU.AR7 v4(109.47,100.48)
  GND w0.089: v4(109.47,100.48) 109.47,100.26 108.26,99.05 108.26,98.67 107.81,98.22 107.53,98.22 104.82,95.51
  GND w0.14: DIMM1.113 78.91,44.58 79.1,44.77 79.1,46.08 79.09,46.08 79.09,46.64 79.94,47.49 79.94,48.69 80.79,49.54 80.79,50.44 81.64,51.29 81.64,52.38 82.1,52.84 82.1,53.23 84.35,55.48 86.48,55.48 87.32,56.32 arc(87.41,56.54) 87.32,56.77 87.09,56.99 arc(87,57.22) 87.09,57.44 87.1,57.44 arc(87.32,57.53) 87.54,57.44 87.77,57.22 arc(88.22,57.22) 88.22,57.67 87.98,57.9 arc(87.98,58.35) 88.43,58.35 88.66,58.12 arc(89.11,58.12) 89.11,58.56 88.87,58.81 arc(88.87,59.26) 89.32,59.26 89.56,59.01 arc(90.01,59.01) 90.01,59.46 89.78,59.69 arc(89.78,60.14) 90.23,60.14 90.46,59.91 arc(90.91,59.91) 90.91,60.36 90.69,60.58 arc(90.6,60.8) 90.69,61.02 90.69,61.03 arc(90.92,61.12) 91.14,61.03 91.36,60.81 arc(91.59,60.72) 91.81,60.81 99.73,68.73 99.73,79.55 99.73,79.66 101.05,80.98 101.05,91.74 104.82,95.51
M_DATA_B47: length 79.5
  TOP w0.089: CPU.AR6 v4(108.56,100.48)
  GND w0.089: 104.23,95.82 104.49,96.08 104.8,96.08 107.2,98.48 107.2,98.78 108.56,100.14 v4(108.56,100.48)
  GND w0.14: 104.23,95.82 100.41,92 100.41,81.24 99.09,79.92 99.09,69.22 91.86,61.99 89.51,61.99 81.46,53.94 81.46,52.84 81.27,52.65 81.27,52.53 81.27,52.53 81.27,52.23 81.27,52.23 81.27,51.44 80.42,50.59 80.42,49.69 79.57,48.84 79.57,47.64 78.72,46.79 78.72,45.35 78.06,44.69 78.06,41.49 77.22,40.65 77.22,39.41 78.06,38.58 DIMM1.258
M_DATA_B48: length 90.6
  TOP w0.089: CPU.AM9 v4(112.22,104.13)
  GND w0.089: 102.95,99.03 103.15,99.03 106.31,102.19 106.31,102.43 106.81,102.94 111.03,102.94 112.22,104.13 v4(112.22,104.13)
  GND w0.14: 102.95,99.03 97.19,93.27 97.19,89.83 arc(96.87,89.51) 96.55,89.83 96.55,91.8 arc(96.24,92.12) 95.92,91.8 95.92,73.85 arc(95.6,73.53) 95.28,73.85 95.28,74.83 arc(94.97,75.14) 94.65,74.83 94.65,72.13 74.84,52.33 74.84,51.29 73.99,50.44 73.99,49.18 74.47,48.7 74.47,47.35 73.99,46.87 73.99,42.05 DIMM1.119
M_DATA_B49: length 91.7
  TOP w0.089: CPU.AL9 v4(112.22,105.05)
  GND w0.089: v4(112.22,105.05) 111.73,104.56 111.73,103.96 111.47,103.7 110.77,103.7 110.27,103.2 106.66,103.2 105.95,102.48 105.95,102.38 103.94,100.38 103.4,100.38 102.74,99.71
  GND w0.14: 102.74,99.71 95.28,92.26 95.28,76.2 arc(95.19,75.98) 94.97,75.89 94.9,75.89 arc(94.72,75.96) 94.65,76.14 94.65,76.39 arc(94.33,76.7) 94.01,76.39 94.01,72.42 93.44,71.85 93.44,71.83 74.47,52.86 74.47,51.45 73.62,50.6 73.62,48.91 73.06,48.35 73.06,47.47 73.62,46.91 73.62,45.97 72.3,44.65 72.3,43.31 72.77,42.84 72.77,41.4 72.17,40.79 72.17,39.9 72.96,39.12 DIMM1.264
M_DATA_B50: length 90.1
  TOP w0.089: CPU.AL6 v4(108.56,105.07)
  GND w0.089: v4(108.56,105.07) 108.53,105.05 105.72,105.05 104.86,104.19 104.86,103.93 104.1,103.17 103,103.17 102.58,102.75 101.95,102.75
  GND w0.14: DIMM1.126 68.04,40.45 68.04,42.33 68.3,42.59 68.3,45.01 68.89,45.6 68.89,46.83 68.04,47.68 68.04,48.44 68.89,49.29 68.89,50.46 69.74,51.31 69.74,52.13 85.37,67.76 arc(85.46,67.99) 85.37,68.21 85.18,68.4 arc(85.18,68.85) 85.63,68.85 85.82,68.66 arc(86.27,68.66) 86.27,69.11 86.08,69.3 arc(86.08,69.75) 86.53,69.75 86.72,69.56 arc(86.94,69.47) 87.17,69.56 91.17,73.56 91.17,83.99 arc(91.49,84.3) 91.81,83.99 91.81,83.88 arc(92.12,83.56) 92.44,83.88 92.44,93.49 101.7,102.75 101.95,102.75
M_DATA_B51: length 90.9
  TOP w0.089: CPU.AL7 109.93,104.64 v4(109.5,105.07)
  GND w0.089: 101.93,103.38 102.32,103.38 102.57,103.63 103.87,103.63 105.53,105.29 108.02,105.29 108.26,105.54 109.04,105.54 v4(109.5,105.07)
  GND w0.14: DIMM1.271 67.01,40.66 67.67,41.33 67.67,42.65 67.73,42.71 67.73,45.29 68.52,46.08 68.52,46.68 67.67,47.53 67.67,48.78 68.52,49.63 68.52,50.62 69.37,51.47 69.37,52.67 84.2,67.49 84.2,68.82 86.16,70.78 87.49,70.78 90.54,73.83 90.54,84.5 91.64,85.61 91.64,93.59 101.44,103.38 101.93,103.38
M_DATA_B52: length 90.9
  TOP w0.089: CPU.AM10 v4(113.13,103.22)
  GND w0.089: v4(113.13,103.22) 112.65,102.74 112.06,102.74 111.73,102.41 111.73,102.11 111.48,101.85 107.53,101.85 106.31,100.63 106.31,100.28 104.01,97.99 103.7,97.99 103.5,97.78
  GND w0.14: DIMM1.117 75.69,42.05 75.69,46.83 76.38,47.52 76.38,48.46 77.22,49.29 77.22,50.49 78.05,51.33 78.05,52.53 77.76,52.83 77.76,53.45 78.16,53.85 arc(78.38,53.94) 78.61,53.85 78.88,53.58 arc(79.33,53.58) 79.33,54.03 79.06,54.3 arc(78.96,54.52) 79.06,54.75 97.19,72.88 97.19,85.8 arc(97.51,86.12) 97.82,85.8 97.82,82.16 arc(98.14,81.84) 98.46,82.16 98.46,92.74 103.5,97.78
M_DATA_B53: length 91.9
  TOP w0.089: CPU.AL10 v4(113.13,104.13)
  GND w0.089: v4(113.13,104.13) 112.65,103.65 112.05,103.65 111.08,102.69 107.49,102.69 107.14,102.35 107.14,102.1 106.05,101.01 105.77,101.01 104.63,99.87 104.63,99.39 103.84,98.6 103.41,98.6 103.22,98.4
  GND w0.14: DIMM1.262 74.66,38.83 75.32,39.5 75.32,40.82 74.71,41.43 74.71,45.18 75.32,45.79 75.32,46.91 74.84,47.4 74.84,48.53 75.59,49.28 75.59,50.54 76.28,51.22 76.28,52.87 96.55,73.14 96.55,88.49 arc(96.87,88.81) 97.19,88.49 97.19,87.27 arc(97.51,86.95) 97.82,87.27 97.82,93.01 103.22,98.4
M_DATA_B54: length 88.5
  TOP w0.089: CPU.AM6 v4(108.56,104.16)
  GND w0.089: v4(108.56,104.16) 108.34,104.16 107.93,104.57 106.57,104.57 106.33,104.32 106.33,104.08 104.17,101.93 103.18,101.93 102.62,101.37 102.44,101.37
  GND w0.14: 102.44,101.37 102.11,101.37 93.73,92.99 93.73,79.77 arc(93.42,79.45) 93.1,79.77 93.1,81.27 arc(92.78,81.58) 92.46,81.27 92.46,73.06 71.44,52.04 71.44,51.33 70.59,50.48 70.59,49.33 69.74,48.48 69.74,47.67 70.59,46.82 70.59,45.93 69.74,45.08 69.74,40.45 DIMM1.124
M_DATA_B55: length 89.3
  TOP w0.089: CPU.AM7 v4(109.47,104.16)
  GND w0.089: v4(109.47,104.16) 108.99,104.64 108.24,104.64 108.12,104.76 105.85,104.76 105.19,104.1 105.19,103.6 103.94,102.36 102.87,102.36 102.63,102.11 102.29,102.11
  GND w0.14: DIMM1.269 69.28,38.64 69.28,39.36 68.66,39.98 68.66,40.68 69.37,41.4 69.37,42.42 68.89,42.91 68.89,44.75 70.22,46.08 70.22,46.67 69.37,47.52 69.37,48.82 70.22,49.67 70.22,50.63 71.07,51.48 71.07,52.57 91.81,73.3 91.81,82.08 93.09,83.36 93.09,93.24 101.96,102.11 102.29,102.11
M_DATA_B56: length 102.4
  TOP w0.089: CPU.AJ7 v4(109.47,106.88)
  GND w0.089: v4(109.47,106.88) 109.04,107.31 107.42,107.31 106.84,106.73 105.49,106.73 104.06,105.29 102.9,105.29
  GND w0.14: DIMM1.130 64.64,40.45 64.64,42.96 65.49,43.81 65.49,46.81 64.64,47.66 64.64,48.54 65.49,49.39 65.49,50.44 66.34,51.29 66.34,52.46 80.77,66.89 80.77,69.67 arc(81.09,69.99) 81.41,69.67 81.41,68.2 arc(81.73,67.89) 82.04,68.2 82.04,71.75 79.99,73.8 79.99,78.44 88.51,86.96 arc(88.96,86.96) 88.96,86.51 88.06,85.61 arc(88.06,85.16) 88.51,85.16 89.69,86.34 89.69,94.33 100.65,105.29 102.9,105.29
M_DATA_B57: length 102.1
  TOP w0.089: CPU.AH6 v4(109.47,107.79)
  GND w0.089: v4(109.47,107.79) 109.23,107.55 107.18,107.55 106.74,107.11 105.34,107.11 104.16,105.93 103.23,105.93
  GND w0.14: DIMM1.275 63.61,40.76 64.28,41.43 64.28,43.35 65.13,44.2 65.13,46.66 64.28,47.51 64.28,48.81 65.13,49.66 65.13,50.59 65.98,51.44 65.98,53.05 79.35,66.43 79.35,67.15 arc(79.45,67.38) 79.67,67.47 79.82,67.47 arc(80.14,67.79) 79.82,68.1 79.67,68.1 arc(79.35,68.42) 79.67,68.74 79.82,68.74 arc(80.14,69.06) 79.82,69.37 79.67,69.37 arc(79.35,69.69) 79.67,70.01 79.82,70.01 arc(80.14,70.33) 79.82,70.64 79.67,70.64 arc(79.35,70.96) 79.67,71.28 80.66,71.28 arc(80.98,71.6) 80.66,71.91 79.67,71.91 arc(79.45,72.01) 79.35,72.23 79.35,78.57 arc(79.38,78.7) 79.45,78.8 88.96,88.31 arc(88.96,88.76) 88.51,88.76 88.3,88.55 arc(88.1,88.47) 87.89,88.55 87.87,88.57 arc(87.78,88.8) 87.87,89.02 89.05,90.2 89.05,94.59 100.38,105.93 103.23,105.93
M_DATA_B58: length 104
  TOP w0.089: CPU.AF7 v4(110.39,108.7)
  GND w0.089: v4(110.39,108.7) 109.93,109.16 109.93,109.81 109.42,110.32 106.85,110.32 105.68,109.14 104.81,109.14 104.05,108.38 102.55,108.38 102.15,108.78
  GND w0.14: DIMM1.137 58.51,44.57 60.03,46.08 60.03,46.64 59.54,47.12 59.54,48.42 60.39,49.27 60.39,50.44 61.24,51.29 61.24,52.42 76.53,67.71 76.53,81.81 83.94,89.23 arc(83.94,89.67) 83.49,89.67 81.88,88.06 arc(81.43,88.06) 81.43,88.51 86,93.08 86,95.56 99.22,108.78 102.15,108.78
M_DATA_B59: length 104.3
  TOP w0.089: CPU.AE7 v4(110.39,109.62)
  GND w0.089: 103.06,108.76 104.05,108.76 104.67,109.39 105.49,109.39 106.69,110.58 109.58,110.58 110.39,109.78 v4(110.39,109.62)
  GND w0.14: DIMM1.282 57.66,38.85 58.46,39.65 58.46,40.79 57.73,41.52 57.73,44.67 58.58,45.52 58.58,46.77 59.18,47.37 59.18,48.9 60.03,49.75 60.03,50.63 60.88,51.48 60.88,52.96 75.9,67.98 75.9,82.14 80.65,86.89 80.65,88.62 85.37,93.35 85.37,95.83 98.96,109.42 102.4,109.42 103.06,108.76
M_DATA_B60: length 103.1
  TOP w0.089: CPU.AH7 109.93,107.29 v4(110.35,106.87)
  GND w0.089: 101.93,104.02 103.83,104.02 105.34,105.53 107.82,105.53 108.13,105.85 108.13,106.14 108.14,106.14 108.14,106.15 108.41,106.43 109.92,106.43 v4(110.35,106.87)
  GND w0.14: DIMM1.128 66.34,40.45 66.34,42.46 67.19,43.31 67.19,46.82 66.34,47.67 66.34,48.36 67.19,49.22 67.19,50.46 68.04,51.31 68.04,52.27 83.45,67.67 83.45,68.96 85.9,71.42 86.98,71.42 89.88,74.32 89.88,78.27 87.34,80.81 87.34,82.03 arc(87.66,82.34) 87.98,82.03 87.98,81.29 arc(88.3,80.97) 88.61,81.29 88.61,83.16 arc(88.93,83.48) 89.25,83.16 89.25,80.25 arc(89.57,79.93) 89.88,80.25 89.88,84.74 90.96,85.82 90.96,93.8 101.17,104.02 101.93,104.02
M_DATA_B61: length 101.5
  TOP w0.089: CPU.AJ6 v4(108.56,106.88)
  GND w0.089: v4(108.56,106.88) 108.41,106.88 107.93,106.4 105.62,106.4 104.26,105.03 103.48,105.03 103.1,104.66 102.8,104.66
  GND w0.14: DIMM1.273 65.31,40.79 65.98,41.46 65.98,42.87 66.83,43.72 66.83,46.65 65.98,47.5 65.98,48.53 66.83,49.38 66.83,50.63 67.67,51.48 67.67,52.8 82.68,67.8 82.68,72.05 80.62,74.11 80.62,78.18 86.98,84.54 arc(87.43,84.54) 87.43,84.09 85.32,81.98 arc(85.32,81.53) 85.77,81.53 90.32,86.08 90.32,94.07 100.91,104.66 102.8,104.66
M_DATA_B62: length 103.3
  TOP w0.089: CPU.AF6 v7(108.56,109.62)
  GND w0.089: 100.7,107.51 104.07,107.51 105.22,108.66 106.13,108.66 107.09,109.62 v7(108.56,109.62)
  GND w0.14: 100.7,107.51 99.75,107.51 87.43,95.19 87.43,92.59 86.13,91.3 arc(86.13,90.85) 86.58,90.85 86.92,91.19 arc(87.08,91.25) 87.24,91.19 87.37,91.06 arc(87.44,90.9) 87.37,90.74 82.14,85.51 arc(82.05,85.28) 82.14,85.06 82.6,84.6 arc(82.6,84.15) 82.16,84.15 81.69,84.61 arc(81.24,84.61) 81.24,84.16 81.71,83.7 arc(81.71,83.25) 81.26,83.25 80.79,83.71 arc(80.34,83.71) 80.34,83.26 80.81,82.8 arc(80.81,82.35) 80.36,82.35 79.9,82.81 arc(79.45,82.81) 79.45,82.37 79.91,81.9 arc(79.91,81.45) 79.46,81.45 79,81.92 arc(78.77,82.01) 78.55,81.92 77.8,81.17 77.8,67.16 62.94,52.3 62.94,51.29 62.09,50.44 62.09,49.27 61.24,48.42 61.24,47.44 61.87,46.81 61.87,43.53 DIMM1.135
M_DATA_B63: length 103.1
  TOP w0.089: CPU.AE6 v4(109.47,109.62)
  GND w0.089: 102.03,107.94 104.05,107.94 105,108.9 105.89,108.9 107.03,110.04 109.05,110.04 v4(109.47,109.62)
  GND w0.14: DIMM1.280 59.36,39.03 60.13,39.8 60.13,40.77 59.4,41.5 59.4,44.12 60.39,45.12 60.39,46.84 60.88,47.32 60.88,48.59 61.73,49.44 61.73,50.61 62.58,51.46 62.58,52.84 77.17,67.43 77.17,81.48 85.66,89.98 arc(85.66,90.42) 85.21,90.42 84.88,90.09 arc(84.43,90.09) 84.43,90.54 86.64,92.75 86.64,95.3 99.48,108.15 101.83,108.15 102.03,107.94
M_DATA_B_CB0: length 80.5
  TOP w0.089: CPU.AL25 v4(129.05,104.13)
  GND w0.089: 137.05,87.62 137.05,88.08 136.03,89.91 135.45,91.43 133.84,93.82 133.41,94.25 133.09,94.25 132.73,94.61 132.73,95.04 130.62,97.14 130.06,98.07 130.06,101.94 129.5,103.13 129.5,103.38 v4(129.05,104.13)
  GND w0.14: DIMM1.49 138.4,42.74 140.28,44.62 140.28,46.64 141.13,47.49 141.13,47.49 141.13,48.78 140.28,49.63 140.28,50.59 139.43,51.44 139.43,52.57 139.7,52.84 139.7,52.86 140.54,53.7 140.54,75.8 arc(140.22,76.12) 139.9,75.8 139.9,73.57 arc(139.59,73.26) 139.27,73.57 139.27,76.47 138.86,76.88 138.86,81.97 arc(139.18,82.29) 139.5,81.97 139.5,80.65 arc(139.81,80.33) 140.13,80.65 140.13,82.43 137.05,85.52 137.05,87.62
M_DATA_B_CB1: length 80.3
  TOP w0.089: CPU.AM25 v4(129.05,103.22)
  GND w0.089: v4(129.05,103.22) 129.05,102.91 129.4,102.56 129.84,101.75 129.84,97.82 130.3,96.91 132.44,94.77 132.44,94.56 133.07,93.92 133.19,93.92 133.51,93.6 134.7,91.83 135.58,89.74 136.41,88.21 136.41,87.62
  GND w0.14: 136.41,87.62 136.41,85.26 138.23,83.44 138.23,76.62 138.63,76.21 138.63,70.06 arc(138.95,69.74) 139.27,70.06 139.27,72.28 arc(139.59,72.6) 139.9,72.28 139.9,53.97 139.07,53.13 139.07,51.29 139.92,50.44 139.92,49.36 140.77,48.51 140.77,47.64 139.92,46.79 139.92,46.08 139.56,45.73 139.56,44.92 137.58,42.93 137.58,41.56 136.81,40.79 136.81,39.19 137.55,38.46 137.55,36.47 DIMM1.194
M_DATA_B_CB2: length 76.1
  TOP w0.089: CPU.AR25 v4(128.13,99.56)
  GND w0.089: 133.59,87.62 133.59,87.89 133.87,88.16 133.87,88.97 133.81,89.6 133.46,90.51 132.38,92.13 131.59,92.91 130.96,92.91 129.92,93.95 129.92,94.22 129.63,94.52 129.63,94.77 128.1,96.3 128.1,99.53 v4(128.13,99.56)
  GND w0.14: 133.59,87.62 133.59,84.06 134.09,83.57 134.09,77.81 arc(134.4,77.49) 134.72,77.81 134.72,81.81 arc(135.04,82.13) 135.36,81.81 135.36,75.48 135.67,75.17 135.67,67.84 134.85,67.02 134.85,64.24 135.67,63.42 135.67,54.11 134.13,52.58 134.13,51.32 134.82,50.64 134.82,49.04 134.13,48.35 134.13,47.47 134.82,46.78 134.82,45.73 133.29,44.21 133.29,42.84 132.63,42.18 132.63,40.45 DIMM1.56
M_DATA_B_CB3: length 78.4
  TOP w0.089: CPU.AP26 v4(129.01,101.39)
  GND w0.089: 132.96,87.83 133.55,88.43 133.55,88.69 133.5,89.3 133.12,90.29 132.05,91.89 131.49,92.44 130.73,92.44 129.5,93.67 129.5,94.2 128.68,95.02 128.68,95.3 127.86,96.12 127.86,99.23 127.7,99.39 127.7,99.76 127.99,100.05 128.31,100.05 128.56,100.3 128.56,100.93 v4(129.01,101.39)
  GND w0.14: 132.96,87.83 132.91,87.79 132.91,83.85 133.43,83.33 133.43,76.5 135.03,74.9 135.03,68.36 134.21,67.54 134.21,63.05 arc(134.31,62.82) 134.53,62.73 134.69,62.73 arc(135.01,62.41) 134.69,62.09 134.53,62.09 arc(134.21,61.78) 134.53,61.46 134.69,61.46 arc(135.01,61.14) 134.69,60.82 134.53,60.82 arc(134.21,60.51) 134.53,60.19 134.69,60.19 arc(135.01,59.87) 134.69,59.55 134.53,59.55 arc(134.21,59.24) 134.53,58.92 134.69,58.92 arc(135.01,58.6) 134.69,58.28 134.53,58.28 arc(134.21,57.97) 134.53,57.65 134.69,57.65 arc(135.01,57.33) 134.69,57.01 134.53,57.01 arc(134.21,56.7) 134.53,56.38 134.69,56.38 arc(135.01,56.06) 134.69,55.74 134.53,55.74 arc(134.21,55.43) 134.53,55.11 134.69,55.11 arc(134.91,55.02) 135.01,54.79 135.01,54.67 132.43,52.1 132.43,51.32 133.18,50.57 133.18,49.19 132.39,48.4 132.39,47.55 133.29,46.66 133.29,45.44 132.27,44.41 132.27,41.58 131.6,40.91 DIMM1.201
M_DATA_B_CB4: length 82.2
  TOP w0.089: CPU.AL26 v4(129.96,104.13)
  GND w0.089: v4(129.96,104.13) 130.44,103.66 130.44,103.03 130.58,102.89 130.58,102.57 130.49,102.48 130.49,102.13 130.58,102.04 130.58,101.66 130.49,101.57 130.49,101.21 130.58,101.12 130.58,100.74 130.49,100.65 130.49,100.3 130.58,100.21 130.58,99.83 130.49,99.74 130.49,99.38 130.58,99.29 130.58,98.91 130.49,98.82 130.49,98.47 130.74,98.22 131.07,98.22 131.33,97.96 131.33,97.56 133.86,95.03 134.49,94.26 136.15,91.79 136.64,90.49 138.32,88.26 138.32,87.62
  GND w0.14: DIMM1.47 140.1,42.57 141.98,44.45 141.98,46.68 142.83,47.53 142.83,48.66 141.98,49.51 141.98,50.61 141.13,51.46 141.13,52.04 141.91,52.82 141.91,53.36 143.08,54.53 143.08,56.38 arc(142.76,56.7) 142.44,56.38 142.44,55.05 arc(142.13,54.73) 141.81,55.05 141.81,76.9 141.4,77.3 141.4,84.76 139.55,86.61 arc(139.1,86.61) 139.1,86.16 140.67,84.59 arc(140.67,84.14) 140.22,84.14 138.32,86.05 138.32,87.62
M_DATA_B_CB5: length 80.6
  TOP w0.089: CPU.AM26 v4(129.96,103.22)
  GND w0.089: v4(129.96,103.22) 129.96,102.91 130.27,102.6 130.27,98.28 130.94,97.38 133.11,95.21 133.34,95.21 133.81,94.74 133.81,94.4 134.16,94.04 135.8,91.61 136.38,90.09 137.68,88.13 137.68,87.62
  GND w0.14: 137.68,87.62 137.68,85.78 140.77,82.7 140.77,77.71 arc(140.45,77.4) 140.13,77.71 140.13,79.36 arc(139.81,79.67) 139.5,79.36 139.5,77.14 139.88,76.76 140.75,76.76 141.17,76.34 141.17,53.27 140.77,52.86 140.77,51.3 141.61,50.45 141.61,49.26 142.46,48.41 142.46,47.68 141.61,46.83 141.61,45.97 141.26,45.62 141.26,44.65 139.43,42.82 139.43,41.25 139.92,40.77 139.92,39.35 139.25,38.68 DIMM1.192
M_DATA_B_CB6: length 77.6
  TOP w0.089: CPU.AR26 v4(129.01,99.56)
  GND w0.089: v4(129.01,99.56) 129.01,99.26 128.58,98.83 128.58,96.64 128.82,96.41 129.89,95.92 130.84,94.96 130.84,94.53 131.49,93.88 131.71,93.88 133.03,92.56 134.17,90.88 134.69,89.49 134.69,88.87 134.86,87.96 134.86,87.62
  GND w0.14: DIMM1.54 134.33,40.45 134.33,42.25 134.74,42.66 134.74,43.26 135.64,44.17 135.64,44.92 136.76,46.04 136.76,46.85 137.42,47.51 137.42,48.84 136.69,49.58 136.69,50.3 136.03,50.96 136.03,52.2 136.68,52.85 136.68,53.25 138.21,54.78 138.21,64 arc(137.89,64.32) 137.57,64 137.57,59.48 arc(137.26,59.16) 136.94,59.48 136.94,75.7 136.63,76.01 136.63,82.82 134.86,84.59 134.86,87.62
M_DATA_B_CB7: length 77.9
  TOP w0.089: v4(129.01,100.48) CPU.AP25
  GND w0.089: v4(129.01,100.48) 129.01,100.16 128.56,99.72 128.56,99.22 128.34,99 128.34,96.47 128.79,96.01 129.29,95.75 129.99,95.04 129.99,94.61 131.22,93.38 131.67,93.38 132.7,92.34 133.81,90.7 134.17,89.75 134.23,89.17 134.23,87.62
  GND w0.14: 134.23,87.62 134.23,84.32 135.99,82.56 135.99,75.75 136.3,75.44 136.3,67.09 arc(136.21,66.87) 135.99,66.78 135.86,66.78 arc(135.54,66.46) 135.86,66.14 135.99,66.14 arc(136.3,65.82) 135.99,65.51 135.86,65.51 arc(135.54,65.19) 135.86,64.87 135.99,64.87 arc(136.21,64.78) 136.3,64.55 136.3,55.69 arc(136.62,55.37) 136.94,55.69 136.94,58.16 arc(137.26,58.48) 137.57,58.16 137.57,55.05 135.67,53.15 135.67,51.04 135.18,50.56 135.18,49.14 135.79,48.54 135.79,47.44 135.18,46.84 135.18,45.36 133.97,44.14 133.97,41.5 133.3,40.84 DIMM1.199
M_DQS_A_N0: length 90.2
  TOP w0.089: 146.78,110.27 146.74,110.23 145.93,110.23 144.18,108.48 143.35,108.48 143.15,108.67 142.73,108.67 142.64,108.58 142.11,108.58 141.78,108.25 CPU.AF39
  TOP w0.165: DIMM2.152 172.84,46.36 172.61,46.59 172.61,46.95 173.39,47.74 173.39,48.71 172.55,49.54 172.55,50.53 173.39,51.37 173.39,67.83 176.31,70.75 176.31,86.55 174.26,88.61 174.26,90.4 163.68,100.98 163.68,101.76 155.17,110.27 146.78,110.27
M_DQS_A_N1: length 80.4
  TOP w0.089: CPU.AK39 141.13,104.59 141.05,104.51 141.05,104.3 141.12,104.23 141.64,104.23 141.9,104.49 141.9,104.78 142.04,104.93 142.64,104.93 142.73,105.02 143.15,105.02 143.48,104.69 145.24,104.69 145.72,104.21 146.66,104.21 146.72,104.26
  TOP w0.165: DIMM2.163 163.53,47.6 163.39,47.6 163.2,47.79 163.2,48.64 162.35,49.48 162.35,50.51 163.18,51.34 163.18,66.18 169.04,72.03 169.04,81.72 163.96,86.8 163.96,88.61 157.67,94.9 157.67,99.21 152.62,104.26 146.72,104.26
M_DQS_A_N2: length 67.8
  TOP w0.089: CPU.AP39 141.71,100.93 142.04,101.27 142.64,101.27 142.73,101.36 143.15,101.36 143.59,100.92 143.66,100.92 144.77,99.8 144.77,99.51 145.08,99.2 145.15,99.2 145.17,99.19
  TOP w0.165: 145.17,99.19 146.1,98.25 146.1,95.95 145.79,95.64 145.79,94.66 147.82,92.64 149.83,92.64 151.66,90.8 151.66,88.8 152.4,88.06 152.4,71.85 153.67,70.58 153.67,68.95 arc(153.49,68.52) 153.06,68.34 152.68,68.34 arc(152.36,68.03) 152.68,67.71 153.06,67.71 arc(153.67,67.1) 153.06,66.49 152.68,66.49 arc(152.36,66.17) 152.68,65.85 153.06,65.85 arc(153.49,65.67) 153.67,65.24 153.67,54.32 154.7,53.3 154.7,51.36 153.83,50.5 153.83,49.48 154.69,48.63 154.69,47.67 154.4,47.38 154.4,46.51 DIMM2.174
M_DQS_A_N3: length 56
  TOP w0.089: CPU.AU36 138.57,98.11 138.57,97.91 139.09,97.39 139.09,96.11 139.19,96.01 139.19,95.37 139.08,95.27 139.08,94.9 140.37,93.61 140.37,93.24 140.42,93.19
  TOP w0.165: 140.42,93.19 140.42,89.02 144.89,84.54 144.89,68.48 144.34,67.92 144.34,67.14 144.74,66.74 144.74,65.77 143.62,64.65 143.62,54.14 144.5,53.26 144.5,51.3 143.65,50.45 143.65,49.38 144.48,48.55 144.48,47.87 144.71,47.65 145.05,47.65 145.2,47.8 DIMM2.185
M_DQS_A_N4: length 63.8
  TOP w0.089: CPU.AW7 109.88,97.33 109.7,97.33 109.59,97.22 109.59,96.08 109.51,96 109.51,94.77 108.94,94.19 108.94,93.76 108.99,93.71
  TOP w0.165: 108.99,93.71 108.99,85.38 106.03,82.43 106.03,65.43 104.15,63.55 102.36,63.55 98.26,59.45 97.33,59.45 94.57,56.69 arc(94.47,56.46) 94.57,56.24 94.66,56.15 arc(94.79,55.83) 94.66,55.51 94.53,55.38 arc(94.12,55.21) 93.7,55.38 arc(93.26,55.38) 93.26,54.93 93.35,54.83 arc(93.48,54.52) 93.35,54.2 93.21,54.06 arc(92.8,53.89) 92.39,54.06 arc(92.17,54.16) 91.94,54.06 90.11,52.23 90.11,51.3 89.26,50.45 89.26,49.47 89.96,48.78 DIMM2.244
M_DQS_A_N5: length 64.8
  TOP w0.089: CPU.AU3 106.17,99.21 105.99,99.21 105.5,98.71 105.07,98.71 104.88,98.52 104.88,97.99 104.65,97.76 104.19,97.76 104.04,97.91 103.69,97.91 103.52,97.74 103.52,96.92 102.28,95.68 102.28,95.61 102.26,95.6
  TOP w0.165: 102.26,95.6 101.41,94.74 101.41,86.63 97.49,82.7 97.49,72.74 91.54,66.79 91.54,62.43 81.61,52.5 81.61,51.3 80.76,50.45 80.76,49.56 79.91,48.71 79.91,47.67 80.11,47.47 80.33,47.47 80.61,47.75 DIMM2.255
M_DQS_A_N6: length 75.3
  TOP w0.089: 99.82,100.77 99.84,100.77 99.9,100.82 100.9,100.82 101.09,101.01 102.74,102.66 103.28,102.66 103.6,102.34 103.95,102.34 104.04,102.42 104.76,102.42 104.98,102.2 105.85,102.2 106.27,102.63 CPU.AN3
  TOP w0.165: 99.82,100.77 98.9,100.77 90.16,92.03 90.16,74.19 85.46,69.49 85.46,66.85 71.83,53.22 71.79,53.22 71.42,52.84 71.42,51.33 70.56,50.48 70.56,49.51 71.36,48.71 71.36,46.46 DIMM2.266
M_DQS_A_N7: length 85.8
  TOP w0.089: 100.41,106.79 100.43,106.79 100.48,106.84 101.05,106.84 101.48,106.41 103.19,106.41 103.6,105.99 103.95,105.99 104.04,106.08 105.61,106.08 105.79,106.26 105.79,106.49 105.93,106.62 106.18,106.62 106.27,106.53 CPU.AJ3
  TOP w0.165: 100.41,106.79 96.15,106.79 83.99,94.62 83.99,90.51 75.56,82.08 75.56,67.7 61.2,53.34 61.2,51.47 62.05,50.62 62.05,49.52 61.26,48.74 61.26,48.02 61.48,47.81 61.76,47.81 DIMM2.277
M_DQS_A_N8: length 54.8
  TOP w0.089: CPU.AU32 135.03,98.19 135.56,97.65 135.56,96.97 135.33,96.73 135.33,96.07 135.51,95.89 135.51,95.53 135.22,95.24 135.22,94.8 135.45,94.56 135.45,88.04 134.78,87.37 134.78,86.98 134.83,86.93 134.83,86.91
  TOP w0.165: DIMM2.196 135.85,49.09 135.14,49.8 135.14,50.44 136,51.31 136,52.63 135.2,53.43 135.2,65.65 135.2,66.18 136.31,67.28 136.31,84.52 134.83,86 134.83,86.91
M_DQS_A_P0: length 90.2
  TOP w0.089: 146.77,109.98 146.71,110.04 146.01,110.04 144.26,108.29 143.61,108.29 143.14,107.82 142.74,107.82 142.65,107.91 141.89,107.91 141.68,107.7 141.02,107.7 140.91,107.8 140.91,108.4 140.79,108.53 140.54,108.53 140.48,108.46 CPU.AF38
  TOP w0.165: DIMM2.153 172.68,47.67 172.91,47.67 173.1,47.86 173.1,48.58 172.26,49.42 172.26,50.65 173.1,51.49 173.1,67.95 176.02,70.87 176.02,86.43 173.97,88.49 173.97,90.28 163.39,100.86 163.39,101.64 155.05,109.98 146.77,109.98
M_DQS_A_P1: length 80.4
  TOP w0.089: CPU.AK38 140.74,104.59 140.86,104.47 140.86,104.22 141.04,104.04 141.72,104.04 141.93,104.25 142.7,104.25 142.79,104.16 143.14,104.16 143.47,104.49 145.17,104.49 145.64,104.02 146.65,104.02 146.69,103.97
  TOP w0.165: DIMM2.164 163.05,47.53 162.91,47.67 162.91,48.52 162.06,49.36 162.06,50.63 162.89,51.46 162.89,66.3 168.75,72.16 168.75,81.6 163.67,86.68 163.67,88.49 157.38,94.78 157.38,99.09 152.5,103.97 146.69,103.97
M_DQS_A_P2: length 67.8
  TOP w0.089: CPU.AP38 140.78,100.93 140.88,100.83 140.88,100.68 141.08,100.48 141.8,100.48 141.91,100.6 142.7,100.6 142.77,100.53 143.17,100.53 143.36,100.73 143.58,100.73 144.58,99.72 144.58,99.43 144.95,99.07 144.95,98.99 144.96,98.98
  TOP w0.165: 144.96,98.98 145.81,98.13 145.81,96.07 145.5,95.76 145.5,94.54 147.69,92.35 149.71,92.35 151.37,90.68 151.37,88.68 152.11,87.94 152.11,71.73 153.38,70.46 153.38,68.95 arc(153.29,68.73) 153.06,68.63 152.68,68.63 arc(152.07,68.03) 152.68,67.42 153.06,67.42 arc(153.38,67.1) 153.06,66.78 152.68,66.78 arc(152.07,66.17) 152.68,65.56 153.06,65.56 arc(153.29,65.47) 153.38,65.24 153.38,54.2 154.4,53.18 154.4,51.49 153.54,50.62 153.54,49.36 154.4,48.51 154.4,47.79 154.19,47.58 153.82,47.58 153.7,47.71 DIMM2.175
M_DQS_A_P3: length 56.1
  TOP w0.089: 140.13,93.2 140.18,93.25 140.18,93.53 138.89,94.82 138.89,94.99 138.31,95.57 138.31,96.55 138.51,96.75 138.78,96.75 138.89,96.87 138.89,97.03 CPU.AV36
  TOP w0.165: DIMM2.186 144.35,47.59 144.19,47.75 144.19,48.43 143.36,49.26 143.36,50.57 144.21,51.43 144.21,53.14 143.33,54.02 143.33,64.77 144.45,65.89 144.45,66.62 144.04,67.02 144.04,68.04 144.6,68.6 144.6,84.42 140.13,88.9 140.13,93.2
M_DQS_A_P4: length 63.8
  TOP w0.089: 108.69,93.72 108.69,93.73 108.73,93.76 108.73,93.81 108.75,93.83 108.75,94.27 109.32,94.85 109.32,96.08 109.4,96.16 109.4,97.29 109.53,97.42 109.53,97.79 CPU.AV7
  TOP w0.165: DIMM2.245 89.11,47.88 89.23,47.76 89.55,47.76 89.66,47.88 89.66,48.66 88.97,49.35 88.97,50.57 89.82,51.42 89.82,52.36 91.74,54.27 arc(92.17,54.45) 92.6,54.27 arc(92.8,54.19) 93.01,54.27 93.14,54.41 arc(93.19,54.52) 93.14,54.63 93.05,54.72 arc(93.05,55.58) 93.91,55.58 arc(94.12,55.5) 94.32,55.58 94.45,55.72 arc(94.5,55.83) 94.45,55.94 94.36,56.03 arc(94.18,56.46) 94.36,56.9 97.21,59.74 98.14,59.74 102.24,63.84 104.03,63.84 105.74,65.55 105.74,82.55 108.69,85.5 108.69,93.72
M_DQS_A_P5: length 64.9
  TOP w0.089: CPU.AU2 105.19,99.1 104.76,98.67 104.18,98.67 103.33,97.82 103.33,97 102.15,95.82 102.07,95.82 102.06,95.8
  TOP w0.165: 102.06,95.8 101.12,94.86 101.12,86.75 97.19,82.82 97.19,72.86 91.25,66.91 91.25,62.55 81.32,52.62 81.32,51.42 80.46,50.57 80.46,49.68 79.61,48.83 79.61,47.55 79.98,47.18 80.25,47.18 80.41,47.03 80.41,46.63 80.14,46.36 DIMM2.256
M_DQS_A_P6: length 75.3
  TOP w0.089: CPU.AN2 105.79,102.76 105.87,102.69 105.87,102.49 105.77,102.39 105.06,102.39 104.9,102.55 104.9,102.85 104.65,103.1 104.07,103.1 104,103.17 103.58,103.17 103.26,102.85 102.66,102.85 100.96,101.14 100.82,101.01 99.9,101.01 99.84,101.06 99.82,101.06
  TOP w0.165: DIMM2.267 70.41,47.9 70.55,47.76 70.75,47.76 71.07,48.08 71.07,48.59 70.27,49.39 70.27,50.6 71.12,51.46 71.12,52.96 71.67,53.51 71.71,53.51 85.17,66.97 85.17,69.61 89.87,74.31 89.87,92.15 98.78,101.06 99.82,101.06
M_DQS_A_P7: length 85.8
  TOP w0.089: 100.41,107.08 100.43,107.08 100.48,107.03 101.13,107.03 101.56,106.6 103.35,106.6 103.6,106.84 104.02,106.84 104.11,106.76 104.68,106.76 105.01,106.42 CPU.AJ2
  TOP w0.165: DIMM2.278 60.97,46.45 60.97,48.86 61.76,49.64 61.76,50.5 60.91,51.35 60.91,53.46 75.27,67.82 75.27,82.2 83.69,90.63 83.69,94.74 96.03,107.08 100.41,107.08
M_DQS_A_P8: length 54.9
  TOP w0.089: CPU.AV32 134.91,97.2 134.75,97.2 134.65,97.29 134.65,97.69 134.76,97.8 135.12,97.8 135.35,97.56 135.35,97.06 135.06,96.77 134.87,96.77 134.65,96.55 134.65,95.54 135.03,95.16 135.03,94.72 135.26,94.49 135.26,88.12 134.59,87.45 134.59,86.97 134.54,86.92 134.54,86.91
  TOP w0.165: DIMM2.197 135.13,47.83 135.37,47.83 135.56,48.02 135.56,48.96 134.85,49.68 134.85,50.56 135.71,51.43 135.71,52.51 134.91,53.3 134.91,65.53 134.91,65.53 134.91,66.3 136.02,67.4 136.02,84.4 134.54,85.88 134.54,86.91
M_DQS_B_N0: length 106.6
  TOP w0.089: v4(137.28,108.7) CPU.AF34
  GND w0.089: 144.7,110.63 144.65,110.57 144.27,110.57 143.34,109.64 142.55,109.64 142.32,109.42 141.34,109.42 141.13,109.21 137.78,109.21 v4(137.28,108.7)
  GND w0.14: DIMM1.152 173.24,37.16 173.39,37.3 173.39,38.89 172.5,39.78 172.5,40.54 173.34,41.38 173.34,43.01 173.03,43.32 173.03,45.41 172.5,45.93 172.5,46.59 173.37,47.46 173.37,48.4 172.5,49.26 172.5,50.51 173.39,51.4 173.39,65.41 177.21,69.22 177.21,87.01 164.15,100.07 164.15,101.95 155.46,110.63 144.7,110.63
M_DQS_B_N1: length 100.2
  TOP w0.089: v4(135.45,105.05) CPU.AK33
  GND w0.089: v4(135.45,105.05) 135.72,104.78 136.05,104.78 137.1,103.73 139.29,103.73 139.59,104.03 139.59,104.33 139.82,104.56 140.23,104.56 140.33,104.45 142.5,104.45 142.79,104.17 143.25,104.17 143.69,104.61 144.57,104.61 144.6,104.64
  GND w0.14: 144.6,104.64 152.98,104.64 158.11,99.5 158.11,95.76 167.36,86.51 167.36,84.69 171.19,80.86 171.19,71.7 165.81,66.31 165.81,53.57 164.88,52.64 164.88,51.36 164.07,50.55 164.07,49.19 164.88,48.37 164.88,47.6 163.99,46.71 163.99,45.78 164.57,45.21 164.57,43.69 163.23,42.36 163.23,41.5 164.03,40.71 164.03,39.42 163.23,38.63 163.23,37.82 163.43,37.61 163.73,37.61 163.9,37.78 DIMM1.163
M_DQS_B_N2: length 91.8
  TOP w0.089: v4(136.36,101.39) CPU.AN33
  GND w0.089: v4(136.36,101.39) 136.82,100.63 136.82,100.29 137.32,99.78 141.6,99.78 142.71,98.68 143.43,98.68 143.72,98.39 144.41,98.39 144.48,98.46
  GND w0.14: 144.48,98.46 145,98.46 145.67,97.78 145.67,94.26 147.78,92.16 149.62,92.16 154.46,87.32 154.46,83.52 156.84,81.14 162.3,81.14 165.2,78.24 165.2,74.23 155.73,64.76 155.73,53.37 156.37,52.73 156.37,51.29 155.48,50.4 155.48,49.52 156.33,48.67 156.33,47.42 155.48,46.57 155.48,43.84 154.7,43.05 154.7,41.58 155.48,40.79 155.48,39.65 154.72,38.89 154.72,36.64 DIMM1.174
M_DQS_B_N3: length 83.5
  TOP w0.089: CPU.AN29 v4(131.79,102.3)
  GND w0.089: v4(131.79,102.3) 131.5,102.02 131.5,101.76 132.36,100.9 132.87,100.9 133.13,100.64 133.13,98.85 133.62,98.35 133.84,98.35 134.21,97.99 134.21,97.54 134.8,96.95 135.75,96.95 136.57,96.13 137.13,96.13 137.35,95.91 137.35,95.3 138.1,94.55 138.16,94.55 138.18,94.53
  GND w0.14: DIMM1.185 145.2,37.83 144.99,37.62 144.7,37.62 144.51,37.81 144.51,38.84 145.32,39.65 145.32,40.54 146.21,41.43 146.21,42.27 147.03,43.08 147.03,46.7 147.86,47.53 147.86,48.37 147.09,49.14 147.09,50.57 146.21,51.46 146.21,52.7 arc(146.22,52.75) 146.25,52.8 148.42,54.97 arc(148.45,55.01) 148.46,55.07 148.46,57.51 arc(147.87,58.11) 147.27,57.51 147.27,55.68 arc(146.95,55.36) 146.63,55.68 146.63,84.76 arc(146.62,84.82) 146.59,84.86 139.52,91.93 139.52,93.19 138.18,94.53
M_DQS_B_N4: length 80.1
  TOP w0.089: CPU.AN13 v4(117.16,102.3)
  GND w0.089: 112.61,94.58 112.57,94.62 112.57,95.31 113.98,96.72 113.98,97.38 114.9,98.31 114.9,100.65 115.16,100.91 115.54,100.91 115.74,101.11 115.74,101.46 116.13,101.85 116.31,101.85 v4(117.16,102.3)
  GND w0.14: 112.61,94.58 112.61,93.1 109.57,90.07 109.57,82.65 108.3,81.38 108.3,78.46 106.64,76.8 106.64,76.68 106.64,73.42 106.64,73.42 106.64,63.92 106.6,63.88 106.6,63.85 95.16,52.41 95.16,51.19 94.35,50.38 94.35,49.21 95.16,48.4 95.16,47.42 94.35,46.61 94.35,45.74 91.31,42.7 90.56,42.7 90.08,42.22 90.08,41.61 90.99,40.69 90.99,39.55 90.08,38.63 90.08,37.53 89.96,37.41 DIMM1.244
M_DQS_B_N5: length 81.4
  TOP w0.089: CPU.AR8 v4(111.3,101.39)
  GND w0.089: v4(111.3,101.39) 111.25,101.44 111.1,101.44 110.9,101.24 110.9,100.91 110.8,100.82 110.8,100.29 110.46,99.94 110.2,99.94 108.97,98.72 108.97,98.13 106.02,95.18 106.02,95.12 106.01,95.1
  GND w0.14: 106.01,95.1 101.96,91.06 101.96,80.6 100.64,79.28 100.64,79.17 100.64,79.17 100.64,70.93 100.64,70.93 100.64,68.35 86.85,54.55 84.74,54.55 83.24,53.05 83.24,51.33 82.98,51.07 82.98,51.07 82.4,50.49 82.4,49.4 81.57,48.57 81.57,47.5 80.77,46.7 80.77,43.73 81.62,42.88 81.62,41.51 80.73,40.62 80.73,39.5 79.84,38.61 79.84,37.83 80.34,37.32 80.64,37.32 80.82,37.51 80.82,37.86 DIMM1.255
M_DQS_B_N6: length 90
  TOP w0.089: v4(111.3,104.13) CPU.AM8
  GND w0.089: v4(111.3,104.13) 111.3,104.41 111.15,104.56 110.91,104.56 109.79,103.44 106.42,103.44 104.34,101.36 103.39,101.36 102.42,100.39 102.42,100.33 102.4,100.31
  GND w0.14: 102.4,100.31 94.65,92.56 94.65,78.85 93.38,77.58 93.38,72.68 92.81,72.11 92.81,72.09 73.09,52.37 73.09,51.29 72.2,50.4 72.2,49.35 71.4,48.55 71.4,47.73 72.25,46.87 72.25,45.67 71.41,44.82 71.41,41.49 70.55,40.63 70.55,39.63 71.41,38.76 71.41,37.64 71.08,37.32 71.08,36.64 DIMM1.266
M_DQS_B_N7: length 102.6
  TOP w0.089: CPU.AG6 v4(108.56,108.7)
  GND w0.089: v4(108.56,108.7) 108.56,108.92 108.48,109 108.14,109 108.07,108.93 108.07,108.42 107.87,108.22 105.52,108.22 104.27,106.97 103.58,106.97 103.24,106.63 102.03,106.63 101.99,106.59
  GND w0.14: DIMM1.277 61.94,38.07 62.3,37.71 62.3,37.48 62.02,37.2 61.56,37.2 61.2,37.56 61.2,38.96 62.01,39.78 62.01,40.54 62.9,41.43 62.9,44.64 63.74,45.48 63.74,46.79 62.91,47.61 62.91,48.39 63.74,49.21 63.74,50.4 64.58,51.23 64.58,52.61 78.72,66.74 78.72,78.96 84.18,84.43 arc(84.36,84.85) 84.18,85.27 83.91,85.54 arc(83.91,85.99) 84.36,85.99 84.63,85.72 arc(85.05,85.55) 85.47,85.72 85.47,85.72 arc(85.65,86.15) 85.47,86.57 85.21,86.83 arc(85.21,87.28) 85.66,87.28 85.92,87.02 arc(86.35,86.84) 86.77,87.02 86.77,87.02 arc(86.94,87.44) 86.77,87.86 86.5,88.13 arc(86.41,88.35) 86.5,88.58 88.42,90.49 88.42,94.89 100.12,106.59 101.99,106.59
M_DQS_B_N8: length 78.2
  TOP w0.089: CPU.AN26 v4(129.05,102.3)
  GND w0.089: v4(129.05,102.3) 129.05,102.26 129.62,101.68 129.62,97.01 131.46,95.17 131.46,94.96 133.13,93.46 133.19,93.37 134.56,91.34 135.64,88.52 135.74,87.85 135.77,87.67 135.78,87.66
  GND w0.14: 135.78,87.66 135.78,84.98 137.58,83.17 137.58,76.37 137.85,76.09 137.85,69.33 arc(137.95,69.1) 138.17,69.01 138.55,69.01 arc(139.15,68.41) 138.55,67.81 138.17,67.81 arc(137.85,67.5) 138.17,67.18 138.55,67.18 arc(139.15,66.58) 138.55,65.99 138.17,65.99 arc(137.85,65.67) 138.17,65.35 138.64,65.35 139.12,64.87 139.12,54.24 138,53.12 138,52.66 137.67,52.33 137.67,51.39 138.54,50.51 138.54,49.54 139.35,48.73 139.35,47.53 138.57,46.75 138.57,46.01 136.63,44.08 136.63,43.53 136.03,42.93 136.03,41.45 135.19,40.62 135.19,39.5 136,38.69 136,37.57 135.38,36.95 135.38,36.68 135.59,36.47 DIMM1.196
M_DQS_B_P0: length 106.6
  TOP w0.089: CPU.AF35 v4(138.19,108.7)
  GND w0.089: 144.7,110.35 144.67,110.38 144.35,110.38 143.42,109.45 142.63,109.45 142.4,109.23 141.42,109.23 141.25,109.06 141.21,109.02 138.29,109.02 138.19,108.92 v4(138.19,108.7)
  GND w0.14: DIMM1.153 172.29,38.07 171.97,37.75 171.97,37.3 172.2,37.07 172.76,37.07 173.11,37.42 173.11,38.77 172.22,39.66 172.22,40.66 173.06,41.49 173.06,42.89 172.75,43.21 172.75,45.29 172.22,45.82 172.22,46.71 173.09,47.57 173.09,48.28 172.22,49.15 172.22,50.62 173.11,51.51 173.11,65.52 176.93,69.34 176.93,86.89 163.87,99.95 163.87,101.83 155.34,110.35 144.7,110.35
M_DQS_B_P1: length 100.2
  TOP w0.089: CPU.AL33 v4(135.45,104.13)
  GND w0.089: 144.61,104.36 144.55,104.42 143.77,104.42 143.33,103.97 142.71,103.97 142.42,104.26 140.54,104.26 140.45,104.17 140.45,103.97 140.21,103.73 139.84,103.73 139.77,103.81 139.63,103.81 139.37,103.54 137.02,103.54 135.97,104.59 135.61,104.59 135.45,104.42 v4(135.45,104.13)
  GND w0.14: DIMM1.164 163.12,36.54 163.12,37.53 162.95,37.7 162.95,38.74 163.75,39.54 163.75,40.59 162.95,41.39 162.95,42.47 164.29,43.81 164.29,45.09 163.71,45.67 163.71,46.83 164.6,47.72 164.6,48.26 163.79,49.07 163.79,50.66 164.6,51.48 164.6,52.76 165.53,53.69 165.53,66.43 170.91,71.81 170.91,80.74 167.08,84.57 167.08,86.4 157.83,95.65 157.83,99.39 152.86,104.36 144.61,104.36
M_DQS_B_P2: length 91.8
  TOP w0.089: CPU.AP33 v4(136.36,100.48)
  GND w0.089: v4(136.36,100.48) 137.24,99.59 137.46,99.59 141.53,99.59 142.63,98.49 143.35,98.49 143.64,98.2 144.48,98.2 144.5,98.18
  GND w0.14: 144.5,98.18 144.88,98.18 145.39,97.67 145.39,94.15 147.66,91.88 149.5,91.88 154.18,87.2 154.18,83.41 156.72,80.86 162.18,80.86 164.92,78.13 164.92,74.34 155.45,64.87 155.45,53.26 156.09,52.61 156.09,51.41 155.2,50.52 155.2,49.4 156.05,48.55 156.05,47.53 155.2,46.69 155.2,43.95 154.42,43.17 154.42,41.46 155.2,40.68 155.2,39.77 154.44,39 154.44,37.32 154.25,37.12 153.61,37.12 153.45,37.28 153.45,37.82 DIMM1.175
M_DQS_B_P3: length 83.5
  TOP w0.089: CPU.AN28 v4(130.91,102.3)
  GND w0.089: 137.98,94.34 137.96,94.35 137.96,94.41 137.12,95.26 136.75,95.26 136.49,95.53 136.49,95.94 135.67,96.76 134.72,96.76 134.72,96.76 134.02,97.46 134.02,97.91 133.76,98.16 133.54,98.16 132.94,98.77 132.94,100.03 132.87,100.1 132.54,100.1 132.3,100.34 132.3,100.69 131.31,101.68 131.31,101.9 v4(130.91,102.3)
  GND w0.14: 137.98,94.34 139.24,93.07 139.24,91.82 146.36,84.7 146.36,55.68 arc(146.95,55.09) 147.55,55.68 147.55,57.51 arc(147.87,57.83) 148.18,57.51 148.18,55.12 145.93,52.87 145.93,51.34 146.81,50.46 146.81,49.03 147.58,48.26 147.58,47.65 146.75,46.81 146.75,43.2 145.93,42.38 145.93,41.54 145.04,40.66 145.04,39.77 144.23,38.95 144.23,37.69 144.35,37.58 DIMM1.186
M_DQS_B_P4: length 80.2
  TOP w0.089: CPU.AN12 v4(116.24,102.3)
  GND w0.089: 112.33,94.58 112.38,94.64 112.38,95.39 113.79,96.8 113.79,97.46 114.71,98.38 114.71,100.73 115.08,101.1 115.46,101.1 115.55,101.19 115.55,101.54 116.05,102.04 116.17,102.04 116.24,102.11 v4(116.24,102.3)
  GND w0.14: 112.33,94.58 112.33,93.22 109.29,90.18 109.29,82.77 108.02,81.5 108.02,78.57 106.36,76.91 106.36,76.8 106.36,64.04 106.32,64 106.32,63.96 94.88,52.52 94.88,51.31 94.07,50.49 94.07,49.1 94.88,48.28 94.88,47.54 94.07,46.73 94.07,45.85 91.19,42.98 90.45,42.98 89.8,42.33 89.8,41.49 90.71,40.58 90.71,39.66 89.8,38.75 89.8,37.65 89.45,37.3 89.13,37.3 88.92,37.52 88.92,37.88 DIMM1.245
M_DQS_B_P5: length 81.5
  TOP w0.089: v4(110.39,101.39) CPU.AP8
  GND w0.089: v4(110.39,101.39) 110.54,101.39 110.71,101.22 110.71,100.99 110.59,100.88 110.22,100.88 109.99,100.64 109.99,100 108.78,98.8 108.78,98.21 105.89,95.32 105.83,95.32 105.81,95.3
  GND w0.14: 105.81,95.3 101.68,91.17 101.68,80.72 100.36,79.4 100.36,79.28 100.36,68.47 86.73,54.83 84.63,54.83 82.96,53.17 82.96,51.45 82.7,51.19 82.7,51.19 82.12,50.6 82.12,49.51 81.29,48.69 81.29,47.62 80.49,46.82 80.49,43.62 81.34,42.76 81.34,41.62 80.45,40.73 80.45,39.61 79.56,38.73 79.56,37.71 80.2,37.07 80.2,36.66 80.01,36.47 DIMM1.256
