# Allegro board ECS H11H4-AI-V1.0-OK.brd (continued)
## Nets (continued)
GND: ATX_12V.1 ATX_12V.2 ATX_POWER.5 ATX_POWER.6 ATX_POWER.11 ATX_POWER.12 BAT1.N BIOS_WP.3 C1.2 C2.1 C3.2 C4.2 C5.1 C6.1 C7.1 C8.1 C9.1 C10.1 C11.1 C12.2 C13.1 C16.1 C17.2 C18.2 C19.2 C20.2 C21.2 C22.2 C23.2 C24.2 C25.2 C28.1 C38.2 C39.2 C40.2 C44.2 C49.1 C54.2 C57.2 C59.2 C63.2 C66.2 C74.2 C75.2 C83.2 C86.1 C88.2 C89.2 C92.1 C105.2 C110.2 C112.2 C113.2 C114.2 C115.2 C116.1 C117.2 C118.2 C119.2 C120.1 C122.1 C123.1 C124.1 C125.1 C126.2 C127.2 C128.1 C129.1 C131.1 C132.2 C133.1 C134.1 C135.1 C136.1 C137.1 C138.2 C139.1 C142.1 C143.1 C145.1 C146.2 C147.2 C148.2 C149.1 C151.1 C152.1 C153.1 C154.1 C155.1 C156.1 C158.2 C159.1 C160.2 C161.2 C163.1 C164.1 C165.2 C168.1 C170.2 C173.1 C174.1 C175.1 C176.1 C177.1 C178.2 C179.1 C181.2 C184.2 C185.2 C186.2 C187.2 C188.2 C189.2 C191.2 C192.2 C193.1 C194.2 C195.1 C196.1 C197.1 C198.1 C199.1 C200.1 C201.2 C202.1 C203.2 C204.2 C205.1 C206.2 C207.2 C208.1 C209.2 C210.2 C211.1 C214.1 C215.2 C217.1 C219.2 C220.1 C222.2 C223.2 C224.2 C225.2 C226.2 C227.2 C231.1 C232.1 C233.2 C235.1 C236.1 C238.2 C239.1 C240.1 C241.1 C243.1 C246.1 C249.1 C250.1 C251.1 C252.1 C253.2 C255.1 C257.2 C261.2 C262.1 C264.2 C265.1 C267.2 C268.2 C269.2 C270.2 C271.2 C272.2 C273.2 C274.2 C275.1 C276.1 C277.2 C278.2 C279.2 C280.2 C281.2 C284.2 C285.2 C286.2 C287.2 C288.2 C289.2 C290.2 C291.1 C292.1 C293.2 C294.2 C295.2 C296.1 C297.2 C298.2 C299.2 C300.2 C301.2 C302.1 C303.2 C306.2 C307.2 C308.2 C309.2 C310.2 C311.2 C312.2 C313.2 C314.2 C315.2 C316.2 C317.2 C318.2 C319.2 C320.2 C321.2 C322.1 C323.1 C324.2 C325.1 C326.1 C327.1 C328.2 C331.2 C332.1 C333.2 C334.1 C335.2 C336.1 C340.2 C341.1 C342.2 C348.2 C349.2 C352.2 C353.2 C354.2 C355.2 C356.2 C357.1 C358.2 C359.1 C360.2 C361.2 C362.2 C363.2 C364.2 C365.2 C366.1 C367.2 C368.2 C369.2 C370.2 C371.2 C372.2 C373.2 C374.2 C375.2 C376.1 C377.2 C378.2 C379.2 C380.2 C381.2 C382.2 C383.1 C385.2 C388.2 C389.1 C390.2 C391.2 C392.2 C393.2 C394.2 C395.2 C396.2 C397.2 C398.2 C399.2 C400.2 C401.2 C402.2 C403.2 C404.2 C405.2 C406.1 C407.2 C408.2 C409.2 C410.2 C411.2 C412.2 C413.2 C414.2 C415.2 C416.2 C417.2 C418.2 C419.2 C420.2 C421.2 C422.2 C423.2 C424.2 C425.2 C426.2 C427.1 C428.2 C429.2 C430.2 C431.2 C432.2 C433.2 C434.2 C435.2 C436.2 C437.2 C438.2 C439.2 C440.2 C441.2 C442.2 C443.1 C444.2 C445.1 C446.1 C447.1 C448.1 C449.2 C450.2 C451.1 C452.2 C453.1 C454.1 C455.2 C456.1 C457.2 C458.2 C459.2 C460.2 C462.1 C463.1 C464.1 C465.1 C466.1 C467.1 C471.2 C475.1 C476.2 C480.2 C482.2 C486.1 C487.1 C488.2 C491.2 C494.2 C495.1 C496.1 C499.1 C501.1 C502.1 C503.1 C507.2 C510.1 C511.2 C512.1 C513.1 C514.1 C515.1 C516.1 C517.1 C518.1 C519.1 C520.1 C521.1 C522.1 C523.1 C525.1 C526.1 C528.2 C529.1 C530.2 C531.1 C532.2 C533.2 C534.1 C536.2 C537.1 C538.2 C539.2 C541.2 C542.2 C543.2 C544.2 C545.2 C546.2 C547.1 C548.1 C549.1 C550.2 C551.2 C552.2 C553.2 C554.2 C555.2 C556.2 C557.2 C558.2 C559.2 C560.2 C561.2 C562.1 C563.1 C564.2 C565.2 C566.2 C567.2 C568.2 C569.2 C570.2 C571.2 C572.2 C573.1 C574.2 C575.2 C576.2 C577.1 C578.1 C579.1 C580.1 C581.2 C582.2 C583.2 C584.2 C585.2 C586.1 C588.2 C589.2 C590.2 C592.2 C593.1 C594.1 C595.2 C596.1 C597.2 CN1.1(A) CN1.3(A) CN1.5(A) CN1.7(A) CN2.1(A) CN2.3(A) CN2.5(A) CN2.7(A) CN3.1(A) CN3.3(A) CN3.5(A) CN3.7(A) CN4.1(A) CN4.3(A) CN4.5(A) CN4.7(A) CODEC.7 COM.5 CPU.A4 CPU.A7 CPU.A11 CPU.A13 CPU.A15 CPU.A17 CPU.A24 CPU.AA3 CPU.AA8 CPU.AA33 CPU.AB5 CPU.AB39 CPU.AC3 CPU.AC6 CPU.AC33 CPU.AC34 CPU.AC35 CPU.AD1 CPU.AD4 CPU.AD6 CPU.AD7 CPU.AD8 CPU.AD33 CPU.AD36 CPU.AD37 CPU.AD38 CPU.AD39 CPU.AD40 CPU.AE3 CPU.AE5 CPU.AE8 CPU.AE33 CPU.AE36 CPU.AF1 CPU.AF5 CPU.AF8 CPU.AF33 CPU.AF36 CPU.AF37 CPU.AF40 CPU.AG1 CPU.AG2 CPU.AG3 CPU.AG4 CPU.AG5 CPU.AG8 CPU.AG33 CPU.AG36 CPU.AH5 CPU.AH8 CPU.AH33 CPU.AH36 CPU.AH37 CPU.AH38 CPU.AH39 CPU.AH40 CPU.AJ1 CPU.AJ4 CPU.AJ5 CPU.AJ8 CPU.AJ31 CPU.AJ32 CPU.AJ33 CPU.AJ34 CPU.AJ35 CPU.AJ36 CPU.AK5 CPU.AK6 CPU.AK7 CPU.AK8 CPU.AK9 CPU.AK10 CPU.AK12 CPU.AK13 CPU.AK15 CPU.AK16 CPU.AK17 CPU.AK18 CPU.AK19 CPU.AK20 CPU.AK23 CPU.AK25 CPU.AK26 CPU.AK28 CPU.AK29 CPU.AK30 CPU.AK36 CPU.AK37 CPU.AK40 CPU.AL1 CPU.AL2 CPU.AL3 CPU.AL4 CPU.AL5 CPU.AL11 CPU.AL14 CPU.AL21 CPU.AL24 CPU.AL27 CPU.AL30 CPU.AL36 CPU.AM5 CPU.AM11 CPU.AM14 CPU.AM17 CPU.AM19 CPU.AM24 CPU.AM27 CPU.AM30 CPU.AM31 CPU.AM32 CPU.AM33 CPU.AM34 CPU.AM35 CPU.AM36 CPU.AM37 CPU.AM38 CPU.AM39 CPU.AM40 CPU.AN1 CPU.AN4 CPU.AN5 CPU.AN6 CPU.AN7 CPU.AN8 CPU.AN9 CPU.AN10 CPU.AN11 CPU.AN14 CPU.AN16 CPU.AN19 CPU.AN22 CPU.AN23 CPU.AN24 CPU.AN27 CPU.AN30 CPU.AN36 CPU.AP5 CPU.AP11 CPU.AP14 CPU.AP24 CPU.AP27 CPU.AP30 CPU.AP36 CPU.AP37 CPU.AP40 CPU.AR1 CPU.AR2 CPU.AR3 CPU.AR4 CPU.AR5 CPU.AR11 CPU.AR14 CPU.AR16 CPU.AR17 CPU.AR18 CPU.AR19 CPU.AR20 CPU.AR21 CPU.AR22 CPU.AR23 CPU.AR24 CPU.AR27 CPU.AR30 CPU.AR31 CPU.AR32 CPU.AR33 CPU.AR34 CPU.AR35 CPU.AR36 CPU.AT5 CPU.AT6 CPU.AT7 CPU.AT8 CPU.AT9 CPU.AT10 CPU.AT11 CPU.AT12 CPU.AT13 CPU.AT14 CPU.AT15 CPU.AT17 CPU.AT24 CPU.AT25 CPU.AT26 CPU.AT27 CPU.AT28 CPU.AT29 CPU.AT30 CPU.AT31 CPU.AT32 CPU.AT34 CPU.AT36 CPU.AT37 CPU.AT38 CPU.AT39 CPU.AT40 CPU.AU1 CPU.AU4 CPU.AU5 CPU.AU7 CPU.AU25 CPU.AU30 CPU.AU34 CPU.AV2 CPU.AV5 CPU.AV9 CPU.AV26 CPU.AV28 CPU.AV30 CPU.AV34 CPU.AV38 CPU.AW3 CPU.AW5 CPU.AW9 CPU.AW30 CPU.AW32 CPU.AW34 CPU.AW36 CPU.AY3 CPU.AY5 CPU.AY7 CPU.AY9 CPU.AY27 CPU.AY30 CPU.B6 CPU.B24 CPU.B26 CPU.B28 CPU.B30 CPU.B38 CPU.C2 CPU.C5 CPU.C8 CPU.C10 CPU.C12 CPU.C14 CPU.C16 CPU.C18 CPU.C20 CPU.C22 CPU.C24 CPU.C31 CPU.C33 CPU.C35 CPU.C37 CPU.D4 CPU.D7 CPU.D24 CPU.D26 CPU.D28 CPU.D30 CPU.D37 CPU.D39 CPU.D40 CPU.E3 CPU.E6 CPU.E9 CPU.E11 CPU.E13 CPU.E15 CPU.E17 CPU.E19 CPU.E21 CPU.E23 CPU.E31 CPU.E33 CPU.E35 CPU.E37 CPU.F1 CPU.F4 CPU.F7 CPU.F10 CPU.F22 CPU.F26 CPU.F28 CPU.F30 CPU.F40 CPU.G3 CPU.G6 CPU.G8 CPU.G11 CPU.G13 CPU.G15 CPU.G17 CPU.G19 CPU.G22 CPU.G31 CPU.G33 CPU.H1 CPU.H4 CPU.H7 CPU.H8 CPU.H9 CPU.H21 CPU.H24 CPU.H26 CPU.H28 CPU.H30 CPU.H35 CPU.H37 CPU.H39 CPU.J3 CPU.J6 CPU.J10 CPU.J12 CPU.J16 CPU.J18 CPU.J20 CPU.J32 CPU.J34 CPU.K1 CPU.K4 CPU.K7 CPU.K14 CPU.K15 CPU.K17 CPU.K19 CPU.K22 CPU.K24 CPU.K26 CPU.K28 CPU.K30 CPU.K33 CPU.K35 CPU.K37 CPU.K39 CPU.L3 CPU.L6 CPU.L9 CPU.L11 CPU.L13 CPU.L32 CPU.M1 CPU.M4 CPU.M7 CPU.M10 CPU.M12 CPU.M15 CPU.M17 CPU.M19 CPU.M21 CPU.M23 CPU.M25 CPU.M27 CPU.M29 CPU.M35 CPU.M37 CPU.M39 CPU.N3 CPU.N6 CPU.N8 CPU.N33 CPU.P1 CPU.P4 CPU.P35 CPU.P37 CPU.P39 CPU.R3 CPU.R6 CPU.R8 CPU.R33 CPU.T1 CPU.T4 CPU.T35 CPU.T37 CPU.T39 CPU.U3 CPU.U6 CPU.U33 CPU.V1 CPU.V8 CPU.V35 CPU.V37 CPU.V39 CPU.W3 CPU.W6 CPU.W33 CPU.Y5 CPU.Y35 CPU.Y37 CPU_FAN.1 D7.P D8.P D9.P D10.P D11.1 D13.P D24.1 D25.1 DIMM1.2 DIMM1.4 DIMM1.6 DIMM1.9 DIMM1.11 DIMM1.13 DIMM1.15 DIMM1.17 DIMM1.20 DIMM1.22 DIMM1.24 DIMM1.26 DIMM1.28 DIMM1.31 DIMM1.33 DIMM1.35 DIMM1.37 DIMM1.39 DIMM1.42 DIMM1.44 DIMM1.46 DIMM1.48 DIMM1.50 DIMM1.53 DIMM1.55 DIMM1.57 DIMM1.94 DIMM1.96 DIMM1.98 DIMM1.101 DIMM1.103 DIMM1.105 DIMM1.107 DIMM1.109 DIMM1.112 DIMM1.114 DIMM1.116 DIMM1.118 DIMM1.120 DIMM1.123 DIMM1.125 DIMM1.127 DIMM1.129 DIMM1.131 DIMM1.134 DIMM1.136 DIMM1.138 DIMM1.139 DIMM1.147 DIMM1.149 DIMM1.151 DIMM1.154 DIMM1.156 DIMM1.158 DIMM1.160 DIMM1.162 DIMM1.165 DIMM1.167 DIMM1.169 DIMM1.171 DIMM1.173 DIMM1.176 DIMM1.178 DIMM1.180 DIMM1.182 DIMM1.184 DIMM1.187 DIMM1.189 DIMM1.191 DIMM1.193 DIMM1.195 DIMM1.198 DIMM1.200 DIMM1.202 DIMM1.239 DIMM1.241 DIMM1.243 DIMM1.246 DIMM1.248 DIMM1.250 DIMM1.252 DIMM1.254 DIMM1.257 DIMM1.259 DIMM1.261 DIMM1.263 DIMM1.265 DIMM1.268 DIMM1.270 DIMM1.272 DIMM1.274 DIMM1.276 DIMM1.279 DIMM1.281 DIMM1.283 DIMM2.2 DIMM2.4 DIMM2.6 DIMM2.9 DIMM2.11 DIMM2.13 DIMM2.15 DIMM2.17 DIMM2.20 DIMM2.22 DIMM2.24 DIMM2.26 DIMM2.28 DIMM2.31 DIMM2.33 DIMM2.35 DIMM2.37 DIMM2.39 DIMM2.42 DIMM2.44 DIMM2.46 DIMM2.48 DIMM2.50 DIMM2.53 DIMM2.55 DIMM2.57 DIMM2.94 DIMM2.96 DIMM2.98 DIMM2.101 DIMM2.103 DIMM2.105 DIMM2.107 DIMM2.109 DIMM2.112 DIMM2.114 DIMM2.116 DIMM2.118 DIMM2.120 DIMM2.123 DIMM2.125 DIMM2.127 DIMM2.129 DIMM2.131 DIMM2.134 DIMM2.136 DIMM2.138 DIMM2.139 DIMM2.140 DIMM2.147 DIMM2.149 DIMM2.151 DIMM2.154 DIMM2.156 DIMM2.158 DIMM2.160 DIMM2.162 DIMM2.165 DIMM2.167 DIMM2.169 DIMM2.171 DIMM2.173 DIMM2.176 DIMM2.178 DIMM2.180 DIMM2.182 DIMM2.184 DIMM2.187 DIMM2.189 DIMM2.191 DIMM2.193 DIMM2.195 DIMM2.198 DIMM2.200 DIMM2.202 DIMM2.239 DIMM2.241 DIMM2.243 DIMM2.246 DIMM2.248 DIMM2.250 DIMM2.252 DIMM2.254 DIMM2.257 DIMM2.259 DIMM2.261 DIMM2.263 DIMM2.265 DIMM2.268 DIMM2.270 DIMM2.272 DIMM2.274 DIMM2.276 DIMM2.279 DIMM2.281 DIMM2.283 EC3.2 EC6.2 EC7.2 EC8.2 EC9.2 EC11.2 EC12.2 EC13.2 EC14.2 EC15.2 EC16.2 EC17.2 EC18.2 EC19.2 EC20.2 EC21.2 EC22.2 EC23.2 EC24.2 EC25.2 EC26.2 EC27.2 EC28.2 EC29.2 EC30.2 F_PANEL.5 F_PANEL.8 F_USB.7 F_USB.8 H2.1 H2.2 H2.3 H2.4 H2.5 H2.6 H2.7 H2.8 H3.1 H3.2 H3.3 H3.4 H3.5 H3.6 H3.7 H3.8 H4.1 H4.2 H4.3 H4.4 H4.5 H4.6 H4.7 H4.8 HDMI.2 HDMI.5 HDMI.8 HDMI.11 HDMI.17 HDMI.20 HDMI.21 HDMI.22 HDMI.23 L31.1 LPT.18 LPT.19 LPT.20 LPT.21 LPT.22 LPT.23 LPT.24 LPT.25 PCH1.A2 PCH1.A3 PCH1.A4 PCH1.A18 PCH1.A25 PCH1.A32 PCH1.A37 PCH1.A42 PCH1.A44 PCH1.AA4 PCH1.AA17 PCH1.AA18 PCH1.AA20 PCH1.AA21 PCH1.AA25 PCH1.AA29 PCH1.AA42 PCH1.AB4 PCH1.AB5 PCH1.AB7 PCH1.AB8 PCH1.AB14 PCH1.AB15 PCH1.AB31 PCH1.AB32 PCH1.AB38 PCH1.AC1 PCH1.AC18 PCH1.AC20 PCH1.AC21 PCH1.AC25 PCH1.AC29 PCH1.AC45 PCH1.AD4 PCH1.AD8 PCH1.AD11 PCH1.AD14 PCH1.AD32 PCH1.AD33 PCH1.AD36 PCH1.AE4 PCH1.AE18 PCH1.AE20 PCH1.AE21 PCH1.AE25 PCH1.AE28 PCH1.AE29 PCH1.AE42 PCH1.AF18 PCH1.AF20 PCH1.AF21 PCH1.AF23 PCH1.AF25 PCH1.AF26 PCH1.AF28 PCH1.AF29 PCH1.AG4 PCH1.AG11 PCH1.AG13 PCH1.AG31 PCH1.AG32 PCH1.AG33 PCH1.AG38 PCH1.AH1 PCH1.AH17 PCH1.AH18 PCH1.AH20 PCH1.AH21 PCH1.AH23 PCH1.AH25 PCH1.AH26 PCH1.AH28 PCH1.AH29 PCH1.AH45 PCH1.AJ10 PCH1.AJ14 PCH1.AJ15 PCH1.AJ17 PCH1.AJ18 PCH1.AJ26 PCH1.AJ28 PCH1.AJ29 PCH1.AJ31 PCH1.AJ32 PCH1.AJ36 PCH1.AK4 PCH1.AK42 PCH1.AL4 PCH1.AL10 PCH1.AL11 PCH1.AL13 PCH1.AL17 PCH1.AL19 PCH1.AL24 PCH1.AL29 PCH1.AL32 PCH1.AL33 PCH1.AL38 PCH1.AM15 PCH1.AM17 PCH1.AM19 PCH1.AM22 PCH1.AM24 PCH1.AM27 PCH1.AM29 PCH1.AM45 PCH1.AN4 PCH1.AN7 PCH1.AN8 PCH1.AN10 PCH1.AN11 PCH1.AN22 PCH1.AN27 PCH1.AN31 PCH1.AN39 PCH1.AP4 PCH1.AP11 PCH1.AR5 PCH1.AR7 PCH1.AR9 PCH1.AR33 PCH1.AR34 PCH1.AR42 PCH1.AT9 PCH1.AT10 PCH1.AT15 PCH1.AT36 PCH1.AU1 PCH1.AU7 PCH1.AU35 PCH1.AU36 PCH1.AU39 PCH1.AU45 PCH1.AV6 PCH1.AV17 PCH1.AV24 PCH1.AV27 PCH1.AV31 PCH1.AV33 PCH1.AW9 PCH1.AW13 PCH1.AW19 PCH1.AW29 PCH1.AW37 PCH1.AY38 PCH1.AY45 PCH1.B1 PCH1.B2 PCH1.B3 PCH1.B6 PCH1.B25 PCH1.B37 PCH1.B40 PCH1.B44 PCH1.B45 PCH1.BA1 PCH1.BB1 PCH1.BB11 PCH1.BB16 PCH1.BB21 PCH1.BB25 PCH1.BB30 PCH1.BB34 PCH1.BC1 PCH1.BC2 PCH1.BD2 PCH1.BD43 PCH1.BD44 PCH1.BD45 PCH1.BE9 PCH1.BE14 PCH1.BE18 PCH1.BE23 PCH1.BE28 PCH1.BE32 PCH1.BE37 PCH1.BE40 PCH1.BE44 PCH1.C2 PCH1.C4 PCH1.C10 PCH1.C28 PCH1.C37 PCH1.C42 PCH1.D10 PCH1.D12 PCH1.D15 PCH1.D16 PCH1.D17 PCH1.D19 PCH1.D21 PCH1.D24 PCH1.D25 PCH1.D27 PCH1.D29 PCH1.D30 PCH1.D31 PCH1.D33 PCH1.D35 PCH1.D36 PCH1.D45 PCH1.E13 PCH1.E15 PCH1.E31 PCH1.E33 PCH1.F8 PCH1.F44 PCH1.G9 PCH1.G42 PCH1.H3 PCH1.H17 PCH1.H19 PCH1.H22 PCH1.H24 PCH1.H27 PCH1.H29 PCH1.H35 PCH1.J3 PCH1.J5 PCH1.J7 PCH1.J10 PCH1.J11 PCH1.J39 PCH1.K4 PCH1.K10 PCH1.K27 PCH1.K33 PCH1.K36 PCH1.K42 PCH1.K43 PCH1.L4 PCH1.L8 PCH1.L12 PCH1.L13 PCH1.L15 PCH1.L41 PCH1.M35 PCH1.M42 PCH1.N4 PCH1.N5 PCH1.N10 PCH1.N15 PCH1.N19 PCH1.N22 PCH1.N24 PCH1.N35 PCH1.N36 PCH1.N41 PCH1.P17 PCH1.P19 PCH1.P22 PCH1.P45 PCH1.R5 PCH1.R10 PCH1.R14 PCH1.R22 PCH1.R29 PCH1.R33 PCH1.R38 PCH1.T1 PCH1.T2 PCH1.T4 PCH1.T42 PCH1.U4 PCH1.U8 PCH1.U10 PCH1.U11 PCH1.U14 PCH1.U15 PCH1.U17 PCH1.U18 PCH1.U28 PCH1.U29 PCH1.U31 PCH1.U32 PCH1.U33 PCH1.U38 PCH1.V3 PCH1.V18 PCH1.V20 PCH1.V21 PCH1.V23 PCH1.V25 PCH1.V29 PCH1.V45 PCH1.W4 PCH1.W8 PCH1.W14 PCH1.W31 PCH1.W32 PCH1.W33 PCH1.W38 PCH1.Y17 PCH1.Y18 PCH1.Y20 PCH1.Y21 PCH1.Y26 PCH1.Y28 PCH1.Y29 PCIE16X.A1 PCIE16X.A4 PCIE16X.A12 PCIE16X.A15 PCIE16X.A18 PCIE16X.A20 PCIE16X.A23 PCIE16X.A24 PCIE16X.A27 PCIE16X.A28 PCIE16X.A31 PCIE16X.A34 PCIE16X.A37 PCIE16X.A38 PCIE16X.A41 PCIE16X.A42 PCIE16X.A45 PCIE16X.A46 PCIE16X.A49 PCIE16X.A51 PCIE16X.A54 PCIE16X.A55 PCIE16X.A58 PCIE16X.A59 PCIE16X.A62 PCIE16X.A63 PCIE16X.A66 PCIE16X.A67 PCIE16X.A70 PCIE16X.A71 PCIE16X.A74 PCIE16X.A75 PCIE16X.A78 PCIE16X.A79 PCIE16X.A82 PCIE16X.B4 PCIE16X.B7 PCIE16X.B13 PCIE16X.B16 PCIE16X.B18 PCIE16X.B21 PCIE16X.B22 PCIE16X.B25 PCIE16X.B26 PCIE16X.B29 PCIE16X.B32 PCIE16X.B35 PCIE16X.B36 PCIE16X.B39 PCIE16X.B40 PCIE16X.B43 PCIE16X.B44 PCIE16X.B47 PCIE16X.B49 PCIE16X.B52 PCIE16X.B53 PCIE16X.B56 PCIE16X.B57 PCIE16X.B60 PCIE16X.B61 PCIE16X.B64 PCIE16X.B65 PCIE16X.B68 PCIE16X.B69 PCIE16X.B72 PCIE16X.B73 PCIE16X.B76 PCIE16X.B77 PCIE16X.B80 PSKM.3 PSKM.9 PSKM.G1 PSKM.G2 PSKM.G3 PSKM.G4 PSKM.G5 Q6.S Q8.S Q14.S Q16.C Q17.C Q18.C Q21.S Q22.S Q23.S Q24.S Q25.E Q26.E Q27.E Q28.E Q29.E Q30.S Q31.S Q32.S Q33.S Q34.S Q35.S Q37.S Q39.E Q41.E Q42.C Q44.S Q46.S Q47.S Q48.E Q49.S Q50.S Q51.S Q52.S Q53.E Q54.E Q55.E Q59.S Q61.E Q62.E Q63.S Q67.C Q68.E Q69.E Q84.1 Q84.4 Q86.1 Q86.4 QCGL1.S1 QCGL1.S2 QCGL1.S3 QCGL2.S1 QCGL2.S2 QCGL2.S3 QCGL3.S1 QCGL3.S2 QCGL3.S3 QCGL4.S1 QCGL4.S2 QCGL4.S3 QCL1.S1 QCL1.S2 QCL1.S3 QCL2.S1 QCL2.S2 QCL2.S3 QCL3.S1 QCL3.S2 QCL3.S3 QCL4.S1 QCL4.S2 QCL4.S3 QCL5.S1 QCL5.S2 QCL5.S3 QCL6.S1 QCL6.S2 QCL6.S3 QD5L1.S1 QD5L1.S2 QD5L1.S3 QN1.S QN2.2 QN3.2 QN5.E QN7.S R15.2 R16.2 R17.2 R36.2 R37.2 R46.2 R53.1 R55.1 R61.2 R65.2 R66.1 R67.1 R68.1 R83.2 R90.2 R105.2 R118.1 R126.2 R128.1 R134.2 R136.2 R138.2 R140.1 R143.1 R144.1 R145.1 R149.1 R158.1 R161.1 R168.1 R176.1 R177.1 R186.1 R191.1 R202.2 R206.2 R211.2 R215.2 R216.2 R219.2 R221.2 R224.2 R227.2 R230.2 R232.2 R242.1 R254.1 R275.1 R283.2 R291.2 R292.2 R296.2 R308.2 R322.2 R323.2 R324.2 R325.2 R326.1 R329.2 R330.2 R356.1 R363.1 R367.2 R368.2 R369.2 R395.2 R397.2 R433.2 R437.2 R439.2 R453.2 R459.2 R460.1 R465.2 R471.2 R490.1 R496.1 R500.2 R510.1 R524.1 R547.2 R552.1 R553.1 R563.2 R566.2 R571.1 R581.2 R593.2 R602.1 R607.2 R620.2 R621.2 R625.1 RJ5.3 RJ6.3 RJ7.3 ROM1.4 RT1.1 RT3.1 SATA1.1 SATA1.4 SATA1.7 SATA1.8 SATA1.9 SATA2.1 SATA2.4 SATA2.7 SATA2.8 SATA2.9 SATA_PWR.3 SATA_PWR.4 SC1.2 SC2.2 SP1.2 SP7.2 SP16.1 SP17.1 SPIROM1.4 TCM.2 TCM.12 TCM.17 U1.2 U2.2 U3.8 U4.24 U4.33 U5.8 U6.8 U7.8 U8.2 U9.2 U10.53 U13.2 U14.4 U14.9 U15.2 U16.6 U16.9 U17.6 U17.9 U18.4 U18.5 U18.11 U18.17 U18.18 U18.19 U18.20 U18.21 U18.22 U19.33 U21.6 U21.9 U22.4 U22.5 U22.11 U22.17 U22.18 U22.19 U22.20 U22.21 U22.22 U23.6 U23.9 U24.11 U24.15 U25.6 U25.9 U26.8 U26.9 U27.3 U28.2 U29.8 U29.9 U30.2 U31.4 U31.5 U31.11 U31.17 U31.18 U31.19 U31.20 U31.21 U31.22 U32.4 U32.11 U32.19 U32.21 U32.22 U33.11 U34.8 U35.4 U35.35 U35.71 U36.8 U37.4 U37.9 U38.5 U38.11 U39.1 U39.6 U39.11 U39.12 U39.13 U39.14 U39.15 USB3F.4 USB3F.7 USB3F.13 USB3F.16 USB3X2.4 USB3X2.7 USB3X2.13 USB3X2.16 USB3X2.G1 USB3X2.G2 USB3X2.G3 USB3X2.G4 VGA.5 VGA.6 VGA.7 VGA.8 VGA.10 VGA.16 VGA.17 X1.3 Y1.3 Y2.3 Y2.4
V2P5U_EN: C486.2 R500.1 R501.2 R502.1 U29.2
VCC3_POK: Q22.D Q23.D R180.2 R247.1 R251.1 R257.1 U39.4
VCC_BG: C589.1 QD5L1.G R602.2 U38.4
VCC_BST: R583.1 U38.1
VCC_EN: C598.2 C600.2 Q86.3 Q86.6 U38.7
VCC_FB: C600.1 R571.2 R584.1 R587.1 R623.1 U38.8
VCC_PHASE: C587.2 L32.1 QD5H1.S1 QD5H1.S2 QD5H1.S3 QD5L1.D1 QD5L1.D2 QD5L1.D3 QD5L1.D4 QD5L1.D5 R570.2 R611.1 U38.2
VCC_POK: R200.2 U38.10
VCC_TG: R569.1 U38.3
VCC_VCC: C586.2 D27.P R608.2 R622.2 U38.6
VCCIO_EN: Q25.C R247.2 R478.2 U22.6
VCCIO_PWRGD: C232.2 R252.2 U22.8
VCCIO_SENSE: CPU.AF4 SP10.1
VCCST_PWRGD: R281.1 R303.2 R317.2
VCCST_PWRGD_CPU: CPU.U2 R281.2 R283.1
VCCTG: QD5H1.G R569.2 R570.1
VDDQ_C1: Q46.D Q47.G R470.1
VDDQ_C2: Q47.D R478.1 R479.1
VDDQ_PWRGD: Q46.G R469.1 U32.8
VSS_SA_IO_SENSE: CPU.AE4 SP15.2
1P0A_EN: C596.2 Q84.3 R619.2 R621.1 U31.6
662_P3: C115.1 CODEC.3
662_P4: CODEC.4 R136.1
662_P9: C112.1 CODEC.9 RJ1.2
+ATX_3VSB: C345.1 C348.1 C349.1 C367.1 C386.1 C393.1 C471.1 C542.1 C557.1 C567.1 L25.2 PCH1.BA24 PCH1.W15 Q40.S R225.1 R337.1 R352.1 R374.2 R375.2 R385.2 R402.2 R403.2 R415.2 R434.2 R518.2 R542.2 R545.2 R575.2 R576.2 R577.2 R609.2 R613.2 RJ2.3 RN22.2(B) RN22.4(B) RN22.6(B) RN22.8(B) ROM1.8 U26.5 U26.6 U35.1 U35.32 U35.64
+ATX_3VSB_FB: C345.2 R352.2 R356.2 U26.7
+ATX_5VSB: ATX_POWER.10 C110.1 C119.1 C122.2 C357.2 C362.1 C535.1 C541.1 C554.1 C595.1 D13.N D24.2 EC26.1 L16.1 Q58.S R448.2 R552.2 R573.1 R585.1 R590.2 R618.1 U15.1 U26.2 U26.3 U26.4
+DDR_VTT: C402.1 C405.1 C419.1 C420.1 C503.2 DIMM1.77 DIMM1.221 DIMM2.77 DIMM2.221 U32.18 U32.20
+DIMM_5VDUAL: C456.2 C526.2 C533.1 EC24.1 L30.2 Q56.D QN4.1 QN4.2 QN4.5 QN4.6 QN4.7 R477.2 R502.2 R557.1 R558.1 R603.1 R604.1 RJ4.3 U29.4
+DRIVER_POWER: R181.2 R184.2 R265.2 R286.2 R338.1 R345.2 R346.1
+DVI_VGA_VCC: F1.2 PFB1.2 R23.2
+DVI_VGA_VCC_F: F1.1 Q9.D
+DVI_VGA_VCC_G: Q9.G R91.1
+LDOVDD: C32.1 C33.1 CODEC.29 L16.2
+RTCVCC: C363.1 C364.1 CLR_CMOS.1 D15.3 PCH1.BA22 R358.1 R360.1
+SPI_3P3V: C399.1 C407.1 D19.3 R438.2 R449.1 R457.1 SPIROM1.8
+USB3VCC2_1: C491.1 C571.1 EC27.1 R547.1 U30.5 U37.7 U37.8 USB3F.1 USB3F.19
+USB3VCC_C1: C1.1 C44.1 C54.1 EC3.1 PSKM.4 PSKM.10 R46.1 RN1.1(A) RN1.3(A) RN1.5(A) RN1.7(A) U8.5 U14.7 U14.8 USB3X2.1 USB3X2.10
+USBVCC0: C74.1 C88.1 EC6.1 R90.1 U13.5 U14.6 USB2_LAN.U1 USB2_LAN.U5
+USBVCC2: C416.1 C439.1 EC22.1 F_USB.1 F_USB.2 R459.1 R509.1 U27.7 U27.8 U28.5
+V_3P3_LAN: C121.2 C136.2 Q15.S R170.2 U15.5
+V_3P3_LAN_G1: C121.1 Q15.G R138.1
+VCORE: C222.1 C223.1 C224.1 C225.1 C226.1 C227.1 C269.1 C270.1 C271.1 C278.1 C279.1 C280.1 C287.1 C288.1 C289.1 C298.1 C299.1 C300.1 C312.1 C313.1 C314.1 C318.1 C319.1 C320.1 CPU.A25 CPU.A26 CPU.A27 CPU.A28 CPU.A29 CPU.A30 CPU.AJ11 CPU.AJ12 CPU.AJ13 CPU.AJ14 CPU.AJ15 CPU.AJ16 CPU.AJ17 CPU.AJ18 CPU.AJ19 CPU.AJ20 CPU.AJ21 CPU.AJ22 CPU.B25 CPU.B27 CPU.B29 CPU.B31 CPU.B32 CPU.B33 CPU.B34 CPU.B35 CPU.B36 CPU.B37 CPU.C25 CPU.C26 CPU.C27 CPU.C28 CPU.C29 CPU.C30 CPU.C32 CPU.C34 CPU.C36 CPU.D25 CPU.D27 CPU.D29 CPU.D31 CPU.D32 CPU.D33 CPU.D34 CPU.D35 CPU.D36 CPU.E24 CPU.E25 CPU.E26 CPU.E27 CPU.E28 CPU.E29 CPU.E30 CPU.E32 CPU.E34 CPU.E36 CPU.F23 CPU.F24 CPU.F25 CPU.F27 CPU.F29 CPU.F31 CPU.F32 CPU.F33 CPU.F34 CPU.G23 CPU.G24 CPU.G25 CPU.G26 CPU.G27 CPU.G28 CPU.G29 CPU.G30 CPU.G32 CPU.H22 CPU.H23 CPU.H25 CPU.H27 CPU.H29 CPU.H31 CPU.H32 CPU.J21 CPU.J22 CPU.J23 CPU.J24 CPU.J25 CPU.J26 CPU.J27 CPU.J28 CPU.J29 CPU.J30 CPU.J31 CPU.K16 CPU.K18 CPU.K20 CPU.K21 CPU.K23 CPU.K25 CPU.K27 CPU.K29 CPU.K31 CPU.L14 CPU.L15 CPU.L16 CPU.L17 CPU.L18 CPU.L19 CPU.L20 CPU.L21 CPU.L22 CPU.L23 CPU.L24 CPU.L25 CPU.L26 CPU.L27 CPU.L28 CPU.L29 CPU.L30 CPU.M13 CPU.M14 CPU.M16 CPU.M18 CPU.M20 CPU.M22 CPU.M24 CPU.M26 CPU.M28 CPU.M30 EC11.1 EC12.1 EC13.1 EC14.1 EC15.1 L17.2 L18.2 L21.2 R124.2 R475.1 SC1.1 SP5.1 SP6.1 SP8.1
+VCORE_PH1: C167.1 L18.1 QCH1.S1 QCH1.S2 QCH1.S3 QCL1.D1 QCL1.D2 QCL1.D3 QCL1.D4 QCL1.D5 QCL4.D1 QCL4.D2 QCL4.D3 QCL4.D4 QCL4.D5 R199.1 R229.2 SP4.1 U17.7
+VCORE_PH1_R: C199.2 R229.1
+VCORE_PH2: C166.1 L17.1 QCH2.S1 QCH2.S2 QCH2.S3 QCL2.D1 QCL2.D2 QCL2.D3 QCL2.D4 QCL2.D5 QCL5.D1 QCL5.D2 QCL5.D3 QCL5.D4 QCL5.D5 R198.1 R228.2 SP3.1 U16.7
+VCORE_PH2_R: C200.2 R228.1
+VCORE_PH3: C228.1 L21.1 QCH3.S1 QCH3.S2 QCH3.S3 QCL3.D1 QCL3.D2 QCL3.D3 QCL3.D4 QCL3.D5 QCL6.D1 QCL6.D2 QCL6.D3 QCL6.D4 QCL6.D5 R239.2 R243.1 SP9.1 U21.7
+VCORE_PH3_R: C202.2 R239.1
+VDIMM: C365.1 C368.1 C372.1 C378.1 C392.1 C409.1 C410.1 C411.1 C412.1 C415.1 C418.1 C421.1 C422.1 C428.1 C429.1 C430.1 C431.1 C432.1 C433.1 C434.1 C435.1 C436.1 C437.1 C438.1 C446.2 C447.2 C448.2 C464.2 C475.2 C492.2 CPU.AT18 CPU.AT21 CPU.AU13 CPU.AU15 CPU.AU19 CPU.AU23 CPU.AV11 CPU.AV17 CPU.AV21 CPU.AW10 CPU.AW14 CPU.AW25 CPU.AY12 CPU.AY16 CPU.AY18 CPU.AY23 DIMM1.7 DIMM1.18 DIMM1.29 DIMM1.40 DIMM1.51 DIMM1.59 DIMM1.61 DIMM1.64 DIMM1.67 DIMM1.70 DIMM1.73 DIMM1.76 DIMM1.80 DIMM1.83 DIMM1.85 DIMM1.88 DIMM1.90 DIMM1.92 DIMM1.99 DIMM1.110 DIMM1.121 DIMM1.132 DIMM1.204 DIMM1.206 DIMM1.209 DIMM1.212 DIMM1.215 DIMM1.217 DIMM1.220 DIMM1.223 DIMM1.226 DIMM1.229 DIMM1.231 DIMM1.233 DIMM1.236 DIMM2.7 DIMM2.18 DIMM2.29 DIMM2.40 DIMM2.51 DIMM2.59 DIMM2.61 DIMM2.64 DIMM2.67 DIMM2.70 DIMM2.73 DIMM2.76 DIMM2.80 DIMM2.83 DIMM2.85 DIMM2.88 DIMM2.90 DIMM2.92 DIMM2.99 DIMM2.110 DIMM2.121 DIMM2.132 DIMM2.204 DIMM2.206 DIMM2.209 DIMM2.212 DIMM2.215 DIMM2.217 DIMM2.220 DIMM2.223 DIMM2.226 DIMM2.229 DIMM2.231 DIMM2.233 DIMM2.236 L29.2 R321.2 R440.1 R454.1 R461.1 R462.1 R472.1 R482.1 R504.2 R514.2 R522.1 R532.2
+VGA_VCC: C8.2 C9.2 C10.2 C12.1 C19.1 C24.1 R23.1 R32.1 R33.1 U1.5 U2.5 U4.17 VGA.9
-ACTIVE_P: C91.1 D7.N R120.2 R121.1 USB2_LAN.13
A20GATE: R555.1 U35.43
ANTI_POP_L: CODEC.47 R111.2
ATX_PSON_L: ATX_POWER.8 C583.1 Q63.G QN7.G R153.1 R545.1 R616.1 U35.73
ATX_PSON_L_C: QN7.D R612.2
ATX_PSON_L_D: D12.G Q14.D RJ2.2
ATX_PSON_L_R: Q14.G R153.2
ATX_PWRGD: ATX_POWER.9 C584.1 R466.2 R528.1 R614.2
ATX_PWRGD_R: C511.1 R528.2 U35.16
AUGND: AUDIO.5 AUDIO.12 AUDIO.22 AUDIO.32 AUDIO.G1 AUDIO.G2 AUDIO.G3 AUDIO.G4 C14.1 C26.1 C30.1 C32.2 C33.2 C34.2 C35.2 C42.1 C46.2 C55.2 C58.2 C61.2 C69.2 C70.2 C71.2 C72.2 C73.2 C99.1 C141.1 C150.1 CODEC.26 CODEC.42 D1.3 D3.3 D4.3 D5.3 D6.3 F_AUDIO.2 F_AUDIO.7 H1.1 H1.2 H1.3 H1.4 H1.5 H1.6 H1.7 H1.8 INT_SPK.2 INT_SPK.5 INT_SPK.6 Q1.E1 Q1.E2 Q2.E1 Q2.E2 Q3.E1 Q3.E2 Q4.E1 Q4.E2 Q5.E1 Q5.E2 Q7.E1 Q7.E2 Q19.E R11.2 R12.2 R20.2 R24.2 R29.2 R42.2 R45.2 R79.1 R81.2 R93.2 R94.2 R95.2 R96.2 R105.1 R134.1 R206.1
BA_PC1: Q41.C RN10.1(A) RN10.3(A) RN10.5(A) RN10.7(A)
BA_PC2: Q41.B R452.2
BAT_54C_P1: D15.1 R318.1
BAT_P2: C327.2 D15.2 R330.1 R337.2
BZ_P: BZ.N C385.1 D18.P RN10.2(B) RN10.4(B) RN10.6(B) RN10.8(B)
CA_REF_RC: C384.2 R433.1
CENTER_TAP: C90.2 C102.1 USB2_LAN.P1
CFG0: CPU.H15 R230.1
CFG1: CPU.F15 R221.1
CFG2: CPU.F16 R215.1
CFG3: CPU.H16 R219.1
CFG4: CPU.F19 R227.1
CFG5: CPU.H18 R232.1
CFG6: CPU.G21 R211.1
CFG7: CPU.H20 R216.1
CFG9: CPU.E16 R234.1
CFG_RCOMP: CPU.M11 R291.1
CHA_D0_EVENT_L: DIMM2.78 R462.2
CHB_D0_EVENT_L: DIMM1.78 R461.2
CLK0_24M: C356.1 PCH1.BC17 R371.1 R372.1
CLK1_24M: C352.1 PCH1.AV19 R365.1
CLKREQB: R193.1 U19.12
CLKRUN_L: PCH1.AW22 R373.1
CLR_CMOS_P3: CLR_CMOS.3 R465.1
COM1_CTS_L: U33.14 U35.126
COM1_DCD_L: U33.19 U35.124
COM1_DSR_L: U33.17 U35.120
COM1_DTR_L: U33.13 U35.123
COM1_NCTS_L: C521.2 COM.8 U33.7
COM1_NDCD_L: C516.2 COM.1 U33.2
COM1_NDSR_L: C518.2 COM.6 U33.4
COM1_NDTR_L: C522.2 COM.4 U33.8
COM1_NRI_L: C523.2 COM.9 R531.1 U33.9
COM1_NRTS_L: C520.2 COM.7 U33.6
COM1_NSIN: C517.2 COM.2 U33.3
COM1_NSOUT: C519.2 COM.3 U33.5
COM1_RI_L: D21.N U35.125
COM1_RI_L_IC: D21.P U33.12
COM1_RTS_L: U33.15 U35.119
COM1_SIN: U33.18 U35.122
COM1_SOUT: U33.16 U35.121
COM_+12V: D22.N U33.1
COPEN_L: C545.1 R550.1 U35.65
CPU_24MCLK_N: CPU.J9 PCH1.F1
CPU_24MCLK_P: CPU.K9 PCH1.G1
CPU_BCLK_N: CPU.W4 PCH1.H2
CPU_BCLK_P: CPU.W5 PCH1.G2
CPU_J11: CPU.J11 STP2.1
CPU_K13: CPU.K13 R292.1
CPU_PCIBCLK_N: CPU.W2 PCH1.J1
CPU_PCIBCLK_P: CPU.W1 PCH1.J2
CPU_PLTRST_L: PCH1.AK2 R235.1
CPU_PM_DOWN: CPU.D8 R238.2
CPU_PM_SYNC: CPU.E8 R299.2
CPU_PWROK: R222.1 R297.2
CPU_PWROK_RC: C194.1 CPU.F8 R222.2
CPU_RST_L_RC: C203.1 CPU.E7 R235.2
CPU_VIDALERT_L: CPU.E39 R266.2
CPU_VIDSCK: CPU.E38 R270.2
CPU_VIDSOUT: CPU.E40 R261.2
CPU_VSS_AB10: PCH1.AB10 SP16.2
CPU_VSS_AB11: PCH1.AB11 SP17.2
DCPRTC: C370.1 PCH1.BA26
DDI1_AUX_N: C48.1 CPU.C13
DDI1_AUX_P: C47.1 CPU.B13
DDI1_TX_N0: C51.1 CPU.D21
DDI1_TX_N1: C53.1 CPU.E22
DDI1_TX_P0: C50.1 CPU.C21
DDI1_TX_P1: C52.1 CPU.D22
DDI3_TX_N0: C27.1 CPU.A14
DDI3_TX_N1: C31.1 CPU.B15
DDI3_TX_N2: C43.1 CPU.A16
DDI3_TX_N3: C56.1 CPU.B17
DDI3_TX_P0: C15.1 CPU.B14
DDI3_TX_P1: C29.1 CPU.C15
DDI3_TX_P2: C41.1 CPU.B16
DDI3_TX_P3: C45.1 CPU.C17
DDR4_DRAMRST_L: DIMM1.58 DIMM2.58 R473.2
DDR_VTT_CNTL: CPU.AC36 R349.1
DDR_VTT_CNTL_EN: C487.2 R495.2 U32.5
DDRVTT_CNTL: D16.2 QN2.3 R359.2
DEPOP_N1: Q17.B R135.1
DEPOP_N2: Q16.B R111.1
DEPOP_N3: Q16.E Q17.E Q18.B R154.1
DEPOP_N4: C138.1 Q18.E R151.2
DEPOP_N5: Q13.B R151.1 R152.2
DIMM_CA_CPU_VREF: C384.1 CPU.AB40 R435.1
DIMM_DQ_B: C400.1 R450.1 R453.1 R454.2
DIMM_DQ_CPU_VREF_A: CPU.AC40 TP5.1
DIMM_DQ_CPU_VREF_B: C387.1 CPU.AC39 R445.1
DIMM_S5: C482.1 Q50.D R487.1 U32.6
DIMM_VRCA_A: R436.1 R437.1 R440.2
DIMM_VREF_CA_A: C394.1 C397.1 C403.1 C413.1 DIMM2.146 R435.2 R436.2
DIMM_VREF_DQ_B: C395.1 C398.1 C404.1 C414.1 DIMM1.146 R445.2 R450.2
DISPA_BCLK: CPU.V3 R311.1
DISPA_BCLK_R: PCH1.AM2 R311.2
DISPA_SDI: PCH1.AN2 R284.2
DISPA_SDI_R: CPU.U1 R284.1
DISPA_SDO: CPU.V2 R312.1
DISPA_SDO_R: PCH1.AM1 R312.2
DMI_RX_N0: CPU.Y4 PCH1.C27
DMI_RX_N1: CPU.AA5 PCH1.B28
DMI_RX_N2: CPU.AB3 PCH1.B29
DMI_RX_N3: CPU.AC5 PCH1.B30
DMI_RX_P0: CPU.Y3 PCH1.B27
DMI_RX_P1: CPU.AA4 PCH1.A28
DMI_RX_P2: CPU.AB4 PCH1.C29
DMI_RX_P3: CPU.AC4 PCH1.A30
DMI_TX_N0: CPU.AC1 PCH1.L27
DMI_TX_N1: CPU.AD2 PCH1.E24
DMI_TX_N2: CPU.AE1 PCH1.G27
DMI_TX_N3: CPU.AF3 PCH1.L29
DMI_TX_P0: CPU.AC2 PCH1.N27
DMI_TX_P1: CPU.AD3 PCH1.G24
DMI_TX_P2: CPU.AE2 PCH1.E26
DMI_TX_P3: CPU.AF2 PCH1.K29
DP_AUX_N: C48.2 U4.3
DP_AUX_P: C47.2 U4.2
DP_CTRLCLK: PCH1.BA5 R302.1
DP_CTRLDATA: PCH1.BC4 R301.1
DP_PWROK1: C570.1 R573.2 R581.1 R582.1
DP_PWROK1_1: Q68.B R582.2
DP_PWROK1_2: Q68.C Q69.B R585.2
DP_TX_N0: C51.2 U4.6
DP_TX_N1: C53.2 U4.8
DP_TX_P0: C50.2 U4.5
DP_TX_P1: C52.2 U4.7
DPG: Q6.D RN2.2(B) RN2.4(B) RN2.6(B) RN2.8(B) RN4.2(B) RN4.4(B) RN4.6(B) RN4.8(B)
DPVGA_DDCCLK: R22.1 U4.15
DPVGA_DDCSDA: R21.1 U4.16
DPVGA_HPD: PCH1.AW4 R37.1 U4.32
DPWROK: C353.1 C507.1 PCH1.AV11 Q69.C R367.1 R518.1 U35.14
DQ_REF_B_RC: C387.2 R439.1
DRAM_RESET_L: C453.2 PCH1.BC14 R471.1 R472.2 R473.1
DVI_CTRLDATA: PCH1.BD6 R322.1
DVI_HPD: PCH1.AY2 R326.2
ECIO_A3VSB: C451.2 C454.2 L25.1 U35.96
EDP_HPD: PCH1.BD7 R329.1
EDP_RCOMP: CPU.M9 R289.1
EUP_SW_N1: C389.2 Q39.B R443.1
EUP_SW_N2: Q39.C R441.2 R448.1
EUP_SW_N3: C390.1 R441.1 R444.2 R539.2
EUP_SW_N4: C535.2 Q58.G R539.1
EUP_SW_N5: C386.2 Q40.G R444.1
FAN_CTL1: R361.2 R362.1 U35.6
FAN_CTL1_R: CPU_FAN.4 R362.2
FAN_TAC1: C488.1 R363.2 R364.2 U35.5
FAN_TAC1_R: CPU_FAN.3 D17.P R364.1 R366.1
FP_2: F_PANEL.11 R606.1
FP_3: F_PANEL.6 R605.2
FP_4: F_PANEL.12 R588.2
FP_5: F_PANEL.14 Q67.E
FP_PWRBTN_L: C534.2 C582.1 D24.3 R590.1 R605.1 U35.72
FP_RST_L: C576.1 D25.3 PCH1.AW1 R592.2
FRONT_JD: AUDIO.23 R115.2
FRONT_L: L11.1 Q4.C1 R48.1 R94.1
FRONT_L1: CODEC.35 EC1.1
FRONT_L2: EC1.2 R48.2
FRONT_L_P: Q4.B1 R7.2
FRONT_LL: AUDIO.24 C71.1 D5.2 L11.2
FRONT_R: L9.1 Q4.C2 R47.1 R96.1
FRONT_R1: CODEC.36 EC2.1
FRONT_R2: EC2.2 R47.2
FRONT_R_P: Q4.B2 R8.2
FRONT_RR: AUDIO.21 C69.1 D5.1 L9.2
FW_CE_N: R609.1 ROM1.1 U35.27
FW_HOLD_L: R613.1 ROM1.7
FW_SCK: R538.1 RN22.3(A) ROM1.6
FW_SCK_R: R538.2 U35.22
FW_SI: R534.1 RN22.1(A) ROM1.5
FW_SI_SH: R534.2 U35.21
FW_SMBCLK: R576.1 TP6.1 U35.48
FW_SMBDA: R577.1 STP33.1 U35.49
FW_SOUT: R589.1 RN22.7(A) U35.45
FW_SOUT_SH: R589.2 ROM1.2
FW_WP_L: RN22.5(A) ROM1.3
GLAN_CLKN: PCH1.D3 U19.16
GLAN_CLKP: PCH1.F2 U19.15
GLAN_RX_N7: C183.2 PCH1.L22
GLAN_RX_P7: C182.2 PCH1.K22
GLAN_TX_N7: C171.2 PCH1.C23
GLAN_TX_P7: C169.2 PCH1.B23
GLED0: F_PANEL.2 Q64.C R603.2
GLED1: F_PANEL.4 Q65.C R604.2
GPD1: PCH1.BB15 R397.1 R403.1
GPD10: PCH1.BA13 R385.1 R432.2
GPP_B7: PCH1.AT24 R421.2
GPP_B18: PCH1.BD28 STP14.1
GPP_D4: PCH1.AM44 R387.2
GPP_E0: PCH1.AG36 R389.1
GPP_E1: PCH1.AG35 R388.1
GPP_E2: PCH1.AG39 R407.1
GPP_E3: PCH1.AD35 R411.1
GPP_E4: PCH1.AD31 R391.1
GPP_E9: BIOS_WP.2 PCH1.AD43 R422.1
GPP_E10: PCH1.AD42 Q42.B R442.1
GPP_F15: PCH1.Y43 R412.1
GPP_F16: D20.1 PCH1.Y41 R423.1
GPP_G15: PCH1.R41 R395.1
GPP_H2: PCH1.BD32 R370.2 R401.1
GPP_H12: PCH1.BD35 STP20.1
GPP_H16: PCH1.BD39 RJ7.2
GPP_H17: PCH1.BE34 RJ6.2
GPP_H18: PCH1.BC36 RJ5.2
GPP_I3: PCH1.BA4 R309.1
GSPI1_MOSI: PCH1.AT29 STP12.1
H_CATERR_L: CPU.D13 STP1.1
H_PECI: CPU.G7 R231.1 R233.1
H_PRDY_L: CPU.B10 R250.2
H_PREQ_L: CPU.B9 R256.2 R260.2
H_SKTOCC_L: CPU.AB35 PCH1.Y44 Q33.G Q34.G R350.2
H_SKTOCC_L_R: Q8.G Q34.D R351.1
H_TCK: CPU.F11 R201.1 R202.1
H_TDI: CPU.G12 R214.1
H_TDO: CPU.H13 R204.1 R210.2
H_THERMTRIP_L: CPU.D11 R313.1 R314.2
H_TMS: CPU.F13 R205.1
H_TRST_L: CPU.F12 R203.2
H_VIDALERT_L: R147.2 R165.2 R266.1 R267.2
H_VIDSCK: R148.2 R166.2 R270.1
H_VIDSOUT: R146.2 R164.2 R261.1 R262.2
HDA_BCLK_R: PCH1.BA9 R336.2
HDA_BITCLK: C114.1 CODEC.6 R336.1
HDA_RST_L: C113.1 CODEC.11 R135.2 R335.1
HDA_RST_L_R: PCH1.BD8 R335.2
HDA_SDIN0: PCH1.BE7 R137.1
HDA_SDO_MED: R615.2 RJ3.2
HDA_SDO_R: PCH1.BB7 R333.2 R615.1
HDA_SDO_R1: ME_DISABLE.2 RJ3.1
HDA_SDO_R_P1: ME_DISABLE.3 R430.1
HDA_SDOUT: CODEC.5 R333.1
HDA_SYNC: CODEC.10 R334.1
HDA_SYNC_R: PCH1.BD9 R334.2
HDD_LED_N: F_PANEL.3 Q66.C
HDD_LED_P: F_PANEL.1 R610.2
HDMI_CLK_N3: C56.2 CHOKE4.4 RN4.7(A) RN5.7(A)
HDMI_CLK_N3_R: CHOKE4.3 HDMI.12 RN5.8(B) U5.5 U5.6
HDMI_CLK_P3: C45.2 CHOKE4.1 RN4.5(A) RN5.5(A)
HDMI_CLK_P3_R: CHOKE4.2 HDMI.10 RN5.6(B) U5.4 U5.7
HDMI_CTRLCLK: PCH1.BE5 Q10.S R101.2
HDMI_CTRLDATA: PCH1.BE6 Q11.S R109.2
HDMI_HPD: PCH1.AV4 Q12.S R103.2
HDMI_HPD_CNN: C75.1 HDMI.19 Q12.D R83.1 U9.1
HDMI_SCL: C59.1 HDMI.15 Q10.D R60.2 U9.4
HDMI_SDA: C66.1 HDMI.16 Q11.D R72.2 U9.3
HDMI_TX_N0: C43.2 CHOKE3.4 RN4.3(A) RN5.3(A)
HDMI_TX_N0_R: CHOKE3.3 HDMI.9 RN5.4(B) U5.2 U5.9
HDMI_TX_N1: C31.2 CHOKE2.4 RN2.7(A) RN3.7(A)
HDMI_TX_N1_R: CHOKE2.3 HDMI.6 RN3.8(B) U3.5 U3.6
HDMI_TX_N2: C27.2 CHOKE1.4 RN2.3(A) RN3.3(A)
HDMI_TX_N2_R: CHOKE1.3 HDMI.3 RN3.4(B) U3.2 U3.9
HDMI_TX_P0: C41.2 CHOKE3.1 RN4.1(A) RN5.1(A)
HDMI_TX_P0_R: CHOKE3.2 HDMI.7 RN5.2(B) U5.1 U5.10
HDMI_TX_P1: C29.2 CHOKE2.1 RN2.5(A) RN3.5(A)
HDMI_TX_P1_R: CHOKE2.2 HDMI.4 RN3.6(B) U3.4 U3.7
HDMI_TX_P2: C15.2 CHOKE1.1 RN2.1(A) RN3.1(A)
HDMI_TX_P2_R: CHOKE1.2 HDMI.1 RN3.2(B) U3.1 U3.10
HDPANEL_DETECT: D11.3 PCH1.R36 R122.2 R414.1
HM_5VDUAL: C489.1 R508.1 R509.2 U35.90
HM_12V: C474.1 R484.1 R485.2 U35.93
HM_VCC: C481.1 R493.1 R494.2 U35.92
HM_VCC3: C485.1 R498.1 R499.2 U35.91
HM_VCORE: C461.1 R475.2 U35.95
HM_VDIMM: C470.1 R482.2 U35.94
HSIN: C171.1 U19.14
HSIP: C169.1 U19.13
HSON: C183.1 U19.18
HSOP: C182.1 U19.17
ILAN_WAKE_L: PCH1.BD11 R226.2
INT_DNOISE: INT_SPK.7 Q19.C R155.2
INT_VIN: C141.2 C150.2 INT_SPK.8 R172.2
ISOLATEB: R217.1 R224.1 U19.20
ITP_PMODE: PCH1.AT2 STP6.1
JDREF: CODEC.40 R79.2
KB_CLK: L2.1 RN1.6(B) U35.78
KB_DATA: L1.1 RN1.8(B) U35.77
KBCLK: C6.2 L2.2 PSKM.5
KBDATA: C2.2 L1.2 PSKM.1
KBRST_L: R379.2 U35.42
KBRST_L_RC: C360.1 PCH1.AT17 R379.1 R382.1
LAN1_RSET: R186.2 U19.31
LAN_DIS_L: PCH1.AR15 R402.1
LAN_LED0: R129.1 U19.27
LAN_LED1: C104.1 R107.1 R131.1 U19.26
LAN_LED1_1G_R: D10.N R107.2 USB2_LAN.12
LAN_LED2: Q67.B R120.1 U19.25
LAN_LED2_100M_R: C95.1 D9.N R129.2 R130.1 USB2_LAN.11
LAN_UGND: R108.2 USB2_LAN.P10
LINE1_JD: AUDIO.33 R114.2
LINE1_L: L8.1 Q7.C1 R25.2 R95.1
LINE1_L1: C37.2 CODEC.23
LINE1_L2: C37.1 R25.1
LINE1_L_P: Q7.B1 R13.2
LINE1_LL: AUDIO.34 C72.1 D6.2 L8.2
LINE1_R: L10.1 Q7.C2 R26.2 R93.1
LINE1_R1: C36.2 CODEC.24
LINE1_R2: C36.1 R26.1
LINE1_R_P: Q7.B2 R14.2
LINE1_RR: AUDIO.31 C70.1 D6.1 L10.2
LINE2_JD: F_AUDIO.10 R39.1
LINE2_L: C14.2 D1.2 F_AUDIO.9 Q2.C1 R20.1 R89.2
LINE2_L1: CODEC.14 EC5.1
LINE2_L2: EC5.2 R89.1
LINE2_L_P: Q2.B1 R3.2
LINE2_R: C26.2 D1.1 F_AUDIO.5 Q2.C2 R24.1 R88.2
LINE2_R1: CODEC.15 EC4.1
LINE2_R2: EC4.2 R88.1
LINE2_R_P: Q2.B2 R4.2
LPC_DRQ0_L: R491.1 U35.2
LPC_FRAME_L: PCH1.BE16 TCM.3 U35.37
LPC_LAD0: PCH1.AT22 TCM.11 U35.38
LPC_LAD1: PCH1.AV22 TCM.10 U35.39
LPC_LAD2: PCH1.AT19 TCM.8 U35.40
LPC_LAD3: PCH1.BD16 TCM.7 U35.41
LPC_PIRQ_L: PCH1.AW17 R384.1
LPC_PME_L: PCH1.W44 R505.1 U35.70
LPCPD_L: PCH1.BC18 R600.2
LPT_ACK_L: CN4.2(B) LPT.10 RN21.7(A) U35.104
LPT_AFD_L: RN15.5(A) U35.108
LPT_BUSY: CN4.4(B) LPT.11 RN21.5(A) U35.103
LPT_D0: RN15.3(A) U35.110
LPT_D1: RN15.1(A) U35.111
LPT_D2: RN16.5(A) U35.112
LPT_D3: RN16.1(A) U35.113
LPT_D4: RN17.7(A) U35.114
LPT_D5: RN17.5(A) U35.115
LPT_D6: RN17.3(A) U35.116
LPT_D7: RN17.1(A) U35.117
LPT_ERR_L: CN1.8(B) LPT.15 RN18.1(A) U35.107
LPT_INIT_L: RN16.7(A) U35.106
LPT_PE: CN4.6(B) LPT.12 RN21.3(A) U35.102
LPT_SLCT: CN4.8(B) LPT.13 RN21.1(A) U35.101
LPT_SLIN_L: RN16.3(A) U35.105
LPT_STB_L: RN15.7(A) U35.109
LPTVCC: C572.1 D26.N R567.2 RN18.2(B) RN18.4(B) RN18.6(B) RN18.8(B) RN19.2(B) RN19.4(B) RN19.6(B) RN19.8(B) RN20.2(B) RN20.4(B) RN20.6(B) RN20.8(B) RN21.2(B) RN21.4(B) RN21.6(B) RN21.8(B)
LRST_L: C568.1 R574.2 U35.46
M_ACT_A_L: CPU.AU24 DIMM2.62
M_ACT_B_L: CPU.AU28 DIMM1.62
M_ALERT_A_L: CPU.AT23 DIMM2.208
M_ALERT_B_L: CPU.AY25 DIMM1.208
M_BA_A0: CPU.AY13 DIMM2.81
M_BA_A1: CPU.AV15 DIMM2.224
M_BA_B0: CPU.AL18 DIMM1.81
M_BA_B1: CPU.AM18 DIMM1.224
M_BG_A0: CPU.AW23 DIMM2.63
M_BG_A1: CPU.AV23 DIMM2.207
M_BG_B0: CPU.AW28 DIMM1.63
M_BG_B1: CPU.AY28 DIMM1.207
M_CKE_A0: CPU.AY24 DIMM2.60
M_CKE_A1: CPU.AW24 DIMM2.203
M_CKE_B0: CPU.AY29 DIMM1.60
M_CKE_B1: CPU.AV29 DIMM1.203
M_CLK_A_N0: CPU.AV18 DIMM2.75
M_CLK_A_N1: CPU.AY17 DIMM2.219
M_CLK_A_P0: CPU.AW18 DIMM2.74
M_CLK_A_P1: CPU.AW17 DIMM2.218
M_CLK_B_N0: CPU.AM21 DIMM1.75
M_CLK_B_N1: CPU.AP21 DIMM1.219
M_CLK_B_P0: CPU.AM20 DIMM1.74
M_CLK_B_P1: CPU.AP22 DIMM1.218
M_CS_A_L0: CPU.AW12 DIMM2.84
M_CS_A_L1: CPU.AU11 DIMM2.89
M_CS_B_L0: CPU.AP17 DIMM1.84
M_CS_B_L1: CPU.AN15 DIMM1.89
M_DATA_A0: CPU.AE40 DIMM2.5
M_DATA_A1: CPU.AE37 DIMM2.150
M_DATA_A2: CPU.AG38 DIMM2.12
M_DATA_A3: CPU.AG37 DIMM2.157
M_DATA_A4: CPU.AE39 DIMM2.3
M_DATA_A5: CPU.AE38 DIMM2.148
M_DATA_A6: CPU.AG39 DIMM2.10
M_DATA_A7: CPU.AG40 DIMM2.155
M_DATA_A8: CPU.AJ40 DIMM2.16
M_DATA_A9: CPU.AJ37 DIMM2.161
M_DATA_A10: CPU.AL38 DIMM2.23
M_DATA_A11: CPU.AL37 DIMM2.168
M_DATA_A12: CPU.AJ39 DIMM2.14
M_DATA_A13: CPU.AJ38 DIMM2.159
M_DATA_A14: CPU.AL39 DIMM2.21
M_DATA_A15: CPU.AL40 DIMM2.166
M_DATA_A16: CPU.AN40 DIMM2.27
M_DATA_A17: CPU.AN37 DIMM2.172
M_DATA_A18: CPU.AR38 DIMM2.34
M_DATA_A19: CPU.AR37 DIMM2.179
M_DATA_A20: CPU.AN39 DIMM2.25
M_DATA_A21: CPU.AN38 DIMM2.170
M_DATA_A22: CPU.AR39 DIMM2.32
M_DATA_A23: CPU.AR40 DIMM2.177
M_DATA_A24: CPU.AV37 DIMM2.38
M_DATA_A25: CPU.AW37 DIMM2.183
M_DATA_A26: CPU.AU35 DIMM2.45
M_DATA_A27: CPU.AV35 DIMM2.190
M_DATA_A28: CPU.AU38 DIMM2.36
M_DATA_A29: CPU.AU37 DIMM2.181
M_DATA_A30: CPU.AT35 DIMM2.43
M_DATA_A31: CPU.AW35 DIMM2.188
M_DATA_A32: CPU.AY8 DIMM2.97
M_DATA_A33: CPU.AU8 DIMM2.242
M_DATA_A34: CPU.AV6 DIMM2.104
M_DATA_A35: CPU.AU6 DIMM2.249
M_DATA_A36: CPU.AW8 DIMM2.95
M_DATA_A37: CPU.AV8 DIMM2.240
M_DATA_A38: CPU.AY6 DIMM2.102
M_DATA_A39: CPU.AW6 DIMM2.247
M_DATA_A40: CPU.AV4 DIMM2.108
M_DATA_A41: CPU.AV3 DIMM2.253
M_DATA_A42: CPU.AT3 DIMM2.115
M_DATA_A43: CPU.AT2 DIMM2.260
M_DATA_A44: CPU.AY4 DIMM2.106
M_DATA_A45: CPU.AW4 DIMM2.251
M_DATA_A46: CPU.AT4 DIMM2.113
M_DATA_A47: CPU.AT1 DIMM2.258
M_DATA_A48: CPU.AP1 DIMM2.119
M_DATA_A49: CPU.AP2 DIMM2.264
M_DATA_A50: CPU.AM3 DIMM2.126
M_DATA_A51: CPU.AM2 DIMM2.271
M_DATA_A52: CPU.AP4 DIMM2.117
M_DATA_A53: CPU.AP3 DIMM2.262
M_DATA_A54: CPU.AM4 DIMM2.124
M_DATA_A55: CPU.AM1 DIMM2.269
M_DATA_A56: CPU.AK1 DIMM2.130
M_DATA_A57: CPU.AK2 DIMM2.275
M_DATA_A58: CPU.AH3 DIMM2.137
M_DATA_A59: CPU.AH2 DIMM2.282
M_DATA_A60: CPU.AK4 DIMM2.128
M_DATA_A61: CPU.AK3 DIMM2.273
M_DATA_A62: CPU.AH4 DIMM2.135
M_DATA_A63: CPU.AH1 DIMM2.280
M_DATA_A_CB0: CPU.AW33 DIMM2.49
M_DATA_A_CB1: CPU.AV33 DIMM2.194
M_DATA_A_CB2: CPU.AU31 DIMM2.56
M_DATA_A_CB3: CPU.AV31 DIMM2.201
M_DATA_A_CB4: CPU.AT33 DIMM2.47
M_DATA_A_CB5: CPU.AU33 DIMM2.192
M_DATA_A_CB6: CPU.AW31 DIMM2.54
M_DATA_A_CB7: CPU.AY31 DIMM2.199
M_DATA_B0: CPU.AE34 DIMM1.5
M_DATA_B1: CPU.AE35 DIMM1.150
M_DATA_B2: CPU.AH34 DIMM1.12
M_DATA_B3: CPU.AH35 DIMM1.157
M_DATA_B4: CPU.AD34 DIMM1.3
M_DATA_B5: CPU.AD35 DIMM1.148
M_DATA_B6: CPU.AG34 DIMM1.10
M_DATA_B7: CPU.AG35 DIMM1.155
M_DATA_B8: CPU.AL34 DIMM1.16
M_DATA_B9: CPU.AL35 DIMM1.161
M_DATA_B10: CPU.AK31 DIMM1.23
M_DATA_B11: CPU.AL31 DIMM1.168
M_DATA_B12: CPU.AK34 DIMM1.14
M_DATA_B13: CPU.AK35 DIMM1.159
M_DATA_B14: CPU.AK32 DIMM1.21
M_DATA_B15: CPU.AL32 DIMM1.166
M_DATA_B16: CPU.AP35 DIMM1.27
M_DATA_B17: CPU.AN34 DIMM1.172
M_DATA_B18: CPU.AN31 DIMM1.34
M_DATA_B19: CPU.AP31 DIMM1.179
M_DATA_B20: CPU.AN35 DIMM1.25
M_DATA_B21: CPU.AP34 DIMM1.170
M_DATA_B22: CPU.AN32 DIMM1.32
M_DATA_B23: CPU.AP32 DIMM1.177
M_DATA_B24: CPU.AM29 DIMM1.38
M_DATA_B25: CPU.AM28 DIMM1.183
M_DATA_B26: CPU.AR29 DIMM1.45
M_DATA_B27: CPU.AR28 DIMM1.190
M_DATA_B28: CPU.AL29 DIMM1.36
M_DATA_B29: CPU.AL28 DIMM1.181
M_DATA_B30: CPU.AP29 DIMM1.43
M_DATA_B31: CPU.AP28 DIMM1.188
M_DATA_B32: CPU.AR12 DIMM1.97
M_DATA_B33: CPU.AP12 DIMM1.242
M_DATA_B34: CPU.AL13 DIMM1.104
M_DATA_B35: CPU.AL12 DIMM1.249
M_DATA_B36: CPU.AR13 DIMM1.95
M_DATA_B37: CPU.AP13 DIMM1.240
M_DATA_B38: CPU.AM13 DIMM1.102
M_DATA_B39: CPU.AM12 DIMM1.247
M_DATA_B40: CPU.AP9 DIMM1.108
M_DATA_B41: CPU.AR9 DIMM1.253
M_DATA_B42: CPU.AP7 DIMM1.115
M_DATA_B43: CPU.AP6 DIMM1.260
M_DATA_B44: CPU.AP10 DIMM1.106
M_DATA_B45: CPU.AR10 DIMM1.251
M_DATA_B46: CPU.AR7 DIMM1.113
M_DATA_B47: CPU.AR6 DIMM1.258
M_DATA_B48: CPU.AM9 DIMM1.119
M_DATA_B49: CPU.AL9 DIMM1.264
M_DATA_B50: CPU.AL6 DIMM1.126
M_DATA_B51: CPU.AL7 DIMM1.271
M_DATA_B52: CPU.AM10 DIMM1.117
M_DATA_B53: CPU.AL10 DIMM1.262
M_DATA_B54: CPU.AM6 DIMM1.124
M_DATA_B55: CPU.AM7 DIMM1.269
M_DATA_B56: CPU.AJ7 DIMM1.130
M_DATA_B57: CPU.AH6 DIMM1.275
M_DATA_B58: CPU.AF7 DIMM1.137
M_DATA_B59: CPU.AE7 DIMM1.282
M_DATA_B60: CPU.AH7 DIMM1.128
M_DATA_B61: CPU.AJ6 DIMM1.273
M_DATA_B62: CPU.AF6 DIMM1.135
M_DATA_B63: CPU.AE6 DIMM1.280
M_DATA_B_CB0: CPU.AL25 DIMM1.49
M_DATA_B_CB1: CPU.AM25 DIMM1.194
M_DATA_B_CB2: CPU.AR25 DIMM1.56
M_DATA_B_CB3: CPU.AP26 DIMM1.201
M_DATA_B_CB4: CPU.AL26 DIMM1.47
M_DATA_B_CB5: CPU.AM26 DIMM1.192
M_DATA_B_CB6: CPU.AR26 DIMM1.54
M_DATA_B_CB7: CPU.AP25 DIMM1.199
M_DQS_A_N0: CPU.AF39 DIMM2.152
M_DQS_A_N1: CPU.AK39 DIMM2.163
M_DQS_A_N2: CPU.AP39 DIMM2.174
M_DQS_A_N3: CPU.AU36 DIMM2.185
M_DQS_A_N4: CPU.AW7 DIMM2.244
M_DQS_A_N5: CPU.AU3 DIMM2.255
M_DQS_A_N6: CPU.AN3 DIMM2.266
M_DQS_A_N7: CPU.AJ3 DIMM2.277
M_DQS_A_N8: CPU.AU32 DIMM2.196
M_DQS_A_P0: CPU.AF38 DIMM2.153
M_DQS_A_P1: CPU.AK38 DIMM2.164
M_DQS_A_P2: CPU.AP38 DIMM2.175
M_DQS_A_P3: CPU.AV36 DIMM2.186
M_DQS_A_P4: CPU.AV7 DIMM2.245
M_DQS_A_P5: CPU.AU2 DIMM2.256
M_DQS_A_P6: CPU.AN2 DIMM2.267
M_DQS_A_P7: CPU.AJ2 DIMM2.278
M_DQS_A_P8: CPU.AV32 DIMM2.197
M_DQS_B_N0: CPU.AF34 DIMM1.152
M_DQS_B_N1: CPU.AK33 DIMM1.163
M_DQS_B_N2: CPU.AN33 DIMM1.174
M_DQS_B_N3: CPU.AN29 DIMM1.185
M_DQS_B_N4: CPU.AN13 DIMM1.244
M_DQS_B_N5: CPU.AR8 DIMM1.255
M_DQS_B_N6: CPU.AM8 DIMM1.266
M_DQS_B_N7: CPU.AG6 DIMM1.277
M_DQS_B_N8: CPU.AN26 DIMM1.196
M_DQS_B_P0: CPU.AF35 DIMM1.153
M_DQS_B_P1: CPU.AL33 DIMM1.164
M_DQS_B_P2: CPU.AP33 DIMM1.175
M_DQS_B_P3: CPU.AN28 DIMM1.186
M_DQS_B_P4: CPU.AN12 DIMM1.245
M_DQS_B_P5: CPU.AP8 DIMM1.256
M_DQS_B_P6: CPU.AL8 DIMM1.267
M_DQS_B_P7: CPU.AG7 DIMM1.278
M_DQS_B_P8: CPU.AN25 DIMM1.197
M_MA_A0: CPU.AW15 DIMM2.79
M_MA_A1: CPU.AU18 DIMM2.72
M_MA_A2: CPU.AU17 DIMM2.216
M_MA_A3: CPU.AV19 DIMM2.71
M_MA_A4: CPU.AT19 DIMM2.214
M_MA_A5: CPU.AU20 DIMM2.213
M_MA_A6: CPU.AV20 DIMM2.69
M_MA_A7: CPU.AU21 DIMM2.211
M_MA_A8: CPU.AT20 DIMM2.68
M_MA_A9: CPU.AT22 DIMM2.66
M_MA_A10: CPU.AY14 DIMM2.225
M_MA_A11: CPU.AU22 DIMM2.210
M_MA_A12: CPU.AV22 DIMM2.65
M_MA_A13: CPU.AV12 DIMM2.232
M_MA_A14: CPU.AV14 DIMM2.228
M_MA_A15: CPU.AY11 DIMM2.86
M_MA_A16: CPU.AW13 DIMM2.82
M_MA_B0: CPU.AL19 DIMM1.79
M_MA_B1: CPU.AL22 DIMM1.72
M_MA_B2: CPU.AM22 DIMM1.216
M_MA_B3: CPU.AM23 DIMM1.71
M_MA_B4: CPU.AP23 DIMM1.214
M_MA_B5: CPU.AL23 DIMM1.213
M_MA_B6: CPU.AW26 DIMM1.69
M_MA_B7: CPU.AY26 DIMM1.211
M_MA_B8: CPU.AU26 DIMM1.68
M_MA_B9: CPU.AW27 DIMM1.66
M_MA_B10: CPU.AP18 DIMM1.225
M_MA_B11: CPU.AU27 DIMM1.210
M_MA_B12: CPU.AV27 DIMM1.65
M_MA_B13: CPU.AR15 DIMM1.232
M_MA_B14: CPU.AL17 DIMM1.228
M_MA_B15: CPU.AP16 DIMM1.86
M_MA_B16: CPU.AN18 DIMM1.82
M_ODT_A0: CPU.AW11 DIMM2.87
M_ODT_A1: CPU.AU14 DIMM2.91
M_ODT_B0: CPU.AM16 DIMM1.87
M_ODT_B1: CPU.AL16 DIMM1.91
M_PARITY_A: CPU.AY15 DIMM2.222
M_PARITY_B: CPU.AL20 DIMM1.222
MIC1_JD: AUDIO.13 R116.2
MIC1_L: L6.1 Q5.C1 R34.2 R45.1 R50.2
MIC1_L1: C68.2 CODEC.21
MIC1_L2: C68.1 R50.1
MIC1_L_P: Q5.B1 R9.2
MIC1_LL: AUDIO.14 C55.1 D4.2 L6.2
MIC1_R: L12.1 Q5.C2 R40.2 R49.2 R81.1
MIC1_R1: C60.2 CODEC.22
MIC1_R2: C60.1 R49.1
MIC1_R_P: Q5.B2 R10.2
MIC1_RR: AUDIO.11 C73.1 D4.1 L12.2
MIC1_VREFO-L: CODEC.28 R34.1
MIC1_VREFO-R: CODEC.32 R40.1
MIC2-VREFO: CODEC.30 D2.3
MIC2-VREFO_L: D2.2 R18.1
MIC2-VREFO_R: D2.1 R19.1
MIC2_JD: F_AUDIO.6 R38.1
MIC2_L: C42.2 D3.2 F_AUDIO.1 Q3.C1 R18.2 R42.1 R44.2
MIC2_L1: C85.1 CODEC.16
MIC2_L2: C85.2 R44.1
MIC2_L_P: Q3.B1 R5.2
MIC2_R: C30.2 D3.1 F_AUDIO.3 Q3.C2 R19.2 R29.1 R43.2
MIC2_R1: C76.1 CODEC.17
MIC2_R2: C76.2 R43.1
MIC2_R_P: Q3.B2 R6.2
MONO_L: C67.1 INT_SPK.1 Q1.C1 R12.1
MONO_L_C: C67.2 CODEC.39
MONO_L_P: Q1.B1 R1.2
MONO_R: C82.1 INT_SPK.3 Q1.C2 R11.1
MONO_R_C: C82.2 CODEC.41
MONO_R_P: Q1.B2 R2.2
MS_CLK: L5.1 RN1.2(B) U35.80
MS_DATA: L4.1 RN1.4(B) U35.79
MSCLK: C13.2 L5.2 PSKM.11
MSDATA: C7.2 L4.2 PSKM.7
MXDIN_0: U11.3 U19.2 USB2_LAN.P3
MXDIN_1: U11.6 U19.5 USB2_LAN.P5
MXDIN_2: U12.3 U19.7 USB2_LAN.P7
MXDIN_3: U12.6 U19.10 USB2_LAN.P9
MXDIP_0: U11.4 U19.1 USB2_LAN.P2
MXDIP_1: U11.1 U19.4 USB2_LAN.P4
MXDIP_2: U12.4 U19.6 USB2_LAN.P6
MXDIP_3: U12.1 U19.9 USB2_LAN.P8
NAFD_L: CN1.2(B) LPT.14 RN15.6(B) RN18.7(A)
NPINIT_L: CN2.2(B) LPT.16 RN16.8(B) RN19.7(A)
NPRD0: CN1.4(B) LPT.2 RN15.4(B) RN18.5(A)
NPRD1: CN1.6(B) LPT.3 RN15.2(B) RN18.3(A)
NPRD2: CN2.4(B) LPT.4 RN16.6(B) RN19.5(A)
NPRD3: CN2.8(B) LPT.5 RN16.2(B) RN19.1(A)
NPRD4: CN3.2(B) LPT.6 RN17.8(B) RN20.7(A)
NPRD5: CN3.4(B) LPT.7 RN17.6(B) RN20.5(A)
NPRD6: CN3.6(B) LPT.8 RN17.4(B) RN20.3(A)
NPRD7: CN3.8(B) LPT.9 RN17.2(B) RN20.1(A)
NSLIN_L: CN2.6(B) LPT.17 RN16.4(B) RN19.3(A)
NSTB_L: C573.2 LPT.1 R567.1 RN15.8(B)
OPC_ZVM_L: CPU.AC38 R353.2
PC_BEEP: CODEC.12 TP3.1
PCH_GPIO24_DIS_ME: Q36.E RJ3.3
PCH_GPIO24_DIS_ME_B: Q36.B R432.1
PCH_GPIO24_DIS_ME_C: Q36.C R431.1
PCH_GPP_F22: D14.2 PCH1.W39 R413.1
PCH_INTRUDER_L: PCH1.BE11 R360.2
PCH_JTAG_TCK: PCH1.AN3 R308.1 TP4.1
PCH_JTAG_TDI: PCH1.AP2 R214.2 R307.2
PCH_JTAG_TDO: PCH1.AP1 R204.2 R300.2
PCH_JTAG_TMS: PCH1.AR2 R205.2 R295.2
PCH_JTAGX: PCH1.AR3 R201.2 R209.2
PCH_PECI: C310.1 PCH1.AL3 R233.2 R296.1
PCH_PLTRST_L: R223.2 R376.2 R574.1
PCH_PWROK: C355.1 PCH1.AW11 Q37.G R316.2 R369.1 R467.2
PCH_PWROK_R: Q45.G R466.1 R467.1
PCH_RI_L: C457.1 PCH1.AV13 Q48.C R415.1
PCH_RI_L_0: Q48.B R524.2 R531.2
PCH_SPI_CLK: PCH1.BC31 R383.2
PCH_SPI_CS1: PCH1.AW31 STP16.1
PCH_SPI_CS2: PCH1.AT31 STP15.1
PCH_SPKR: PCH1.BD26 R452.1 STP28.1
PCH_SYSPWROK: C538.1 PCH1.AY1 Q26.C Q33.D R544.1 U35.29
PCH_THERMTRIP_L: PCH1.AJ3 R313.2
PCH_TRIGIN: PCH1.AK1 R298.1
PCH_TRIGIN_R: CPU.B3 R298.2
PCH_TRIGOUT: CPU.D1 R310.2
PCH_TRIGOUT_R: PCH1.AL2 R310.1
PCH_TRST_L: PCH1.AY5 R203.1
PCH_XDP_CLK_N: PCH1.L1 STP7.1
PCH_XDP_CLK_P: PCH1.L2 STP8.1
PCH_XDP_PRDY_L: PCH1.AT4 R250.1
PCH_XDP_PREQ_L: PCH1.AT3 R256.1
PCHHOT_L: R429.2 U35.75
PCIE16X_CLKREQ_L: PCIE16X.B17 PCIE16X.B31 PCIE16X.B48 PCIE16X.B81 R370.1
PCIE_WAKE_L: PCH1.BC13 PCIE16X.B11 R374.1
PCIERCOMP_N: PCH1.B18 R354.1
PCIERCOMP_P: PCH1.C17 R354.2
PCIRST1_L: D14.1 R241.2 U35.30
PCIRST2_L: R594.2 U35.31
PEG_RCOMP: CPU.L7 R290.2
PEG_RX_N0: CPU.B7 PCIE16X.A17
PEG_RX_N1: CPU.C6 PCIE16X.A22
PEG_RX_N2: CPU.D5 PCIE16X.A26
PEG_RX_N3: CPU.E4 PCIE16X.A30
PEG_RX_N4: CPU.F5 PCIE16X.A36
PEG_RX_N5: CPU.G4 PCIE16X.A40
PEG_RX_N6: CPU.H5 PCIE16X.A44
PEG_RX_N7: CPU.J4 PCIE16X.A48
PEG_RX_N8: CPU.K5 PCIE16X.A53
PEG_RX_N9: CPU.L4 PCIE16X.A57
PEG_RX_N10: CPU.M5 PCIE16X.A61
PEG_RX_N11: CPU.N4 PCIE16X.A65
PEG_RX_N12: CPU.P5 PCIE16X.A69
PEG_RX_N13: CPU.R4 PCIE16X.A73
PEG_RX_N14: CPU.T5 PCIE16X.A77
PEG_RX_N15: CPU.U4 PCIE16X.A81
PEG_RX_P0: CPU.B8 PCIE16X.A16
PEG_RX_P1: CPU.C7 PCIE16X.A21
PEG_RX_P2: CPU.D6 PCIE16X.A25
PEG_RX_P3: CPU.E5 PCIE16X.A29
PEG_RX_P4: CPU.F6 PCIE16X.A35
PEG_RX_P5: CPU.G5 PCIE16X.A39
PEG_RX_P6: CPU.H6 PCIE16X.A43
PEG_RX_P7: CPU.J5 PCIE16X.A47
PEG_RX_P8: CPU.K6 PCIE16X.A52
PEG_RX_P9: CPU.L5 PCIE16X.A56
PEG_RX_P10: CPU.M6 PCIE16X.A60
PEG_RX_P11: CPU.N5 PCIE16X.A64
PEG_RX_P12: CPU.P6 PCIE16X.A68
PEG_RX_P13: CPU.R5 PCIE16X.A72
PEG_RX_P14: CPU.T6 PCIE16X.A76
PEG_RX_P15: CPU.U5 PCIE16X.A80
PEG_TX_C_N0: C213.2 PCIE16X.B15
PEG_TX_C_N1: C218.2 PCIE16X.B20
PEG_TX_C_N2: C229.2 PCIE16X.B24
PEG_TX_C_N3: C237.2 PCIE16X.B28
PEG_TX_C_N4: C245.2 PCIE16X.B34
PEG_TX_C_N5: C247.2 PCIE16X.B38
PEG_TX_C_N6: C254.2 PCIE16X.B42
PEG_TX_C_N7: C258.2 PCIE16X.B46
PEG_TX_C_N8: C266.2 PCIE16X.B51
PEG_TX_C_N9: C283.2 PCIE16X.B55
PEG_TX_C_N10: C305.2 PCIE16X.B59
PEG_TX_C_N11: C329.2 PCIE16X.B63
PEG_TX_C_N12: C338.2 PCIE16X.B67
PEG_TX_C_N13: C343.2 PCIE16X.B71
PEG_TX_C_N14: C346.2 PCIE16X.B75
PEG_TX_C_N15: C350.2 PCIE16X.B79
PEG_TX_C_P0: C212.2 PCIE16X.B14
PEG_TX_C_P1: C216.2 PCIE16X.B19
PEG_TX_C_P2: C221.2 PCIE16X.B23
PEG_TX_C_P3: C234.2 PCIE16X.B27
PEG_TX_C_P4: C242.2 PCIE16X.B33
PEG_TX_C_P5: C248.2 PCIE16X.B37
PEG_TX_C_P6: C256.2 PCIE16X.B41
PEG_TX_C_P7: C259.2 PCIE16X.B45
PEG_TX_C_P8: C263.2 PCIE16X.B50
PEG_TX_C_P9: C282.2 PCIE16X.B54
PEG_TX_C_P10: C304.2 PCIE16X.B58
PEG_TX_C_P11: C330.2 PCIE16X.B62
PEG_TX_C_P12: C339.2 PCIE16X.B66
PEG_TX_C_P13: C344.2 PCIE16X.B70
PEG_TX_C_P14: C347.2 PCIE16X.B74
PEG_TX_C_P15: C351.2 PCIE16X.B78
PEG_TX_N0: C213.1 CPU.A6
PEG_TX_N1: C218.1 CPU.B5
PEG_TX_N2: C229.1 CPU.C4
PEG_TX_N3: C237.1 CPU.D3
PEG_TX_N4: C245.1 CPU.E2
PEG_TX_N5: C247.1 CPU.F3
PEG_TX_N6: C254.1 CPU.G2
PEG_TX_N7: C258.1 CPU.H3
PEG_TX_N8: C266.1 CPU.J2
PEG_TX_N9: C283.1 CPU.K3
PEG_TX_N10: C305.1 CPU.L2
PEG_TX_N11: C329.1 CPU.M3
PEG_TX_N12: C338.1 CPU.N2
PEG_TX_N13: C343.1 CPU.P3
PEG_TX_N14: C346.1 CPU.R1
PEG_TX_N15: C350.1 CPU.T3
PEG_TX_P0: C212.1 CPU.A5
PEG_TX_P1: C216.1 CPU.B4
PEG_TX_P2: C221.1 CPU.C3
PEG_TX_P3: C234.1 CPU.D2
PEG_TX_P4: C242.1 CPU.E1
PEG_TX_P5: C248.1 CPU.F2
PEG_TX_P6: C256.1 CPU.G1
PEG_TX_P7: C259.1 CPU.H2
PEG_TX_P8: C263.1 CPU.J1
PEG_TX_P9: C282.1 CPU.K2
PEG_TX_P10: C304.1 CPU.L1
PEG_TX_P11: C330.1 CPU.M2
PEG_TX_P12: C339.1 CPU.N1
PEG_TX_P13: C344.1 CPU.P2
PEG_TX_P14: C347.1 CPU.R2
PEG_TX_P15: C351.1 CPU.T2
PERSTB: C184.1 R223.1 U19.19
PEX16_100M_N: PCH1.W10 PCIE16X.A14
PEX16_100M_P: PCH1.W11 PCIE16X.A13
PEX16_RST: D14.3 R236.1 R237.1 R241.1
PEX16_RST_L: C206.1 PCIE16X.A11 R237.2
PLTRST_R_N: PCH1.BB27 R376.1
PM_DOWN: PCH1.AH2 R238.1
PM_SYNC: PCH1.AJ4 R299.1
PME_L: PCH1.BD17 R398.1
POL1: R36.1 U4.10
POL2: R41.1 U4.9
POP: Q13.C R1.1 R2.1 R3.1 R4.1 R5.1 R6.1 R7.1 R8.1 R9.1 R10.1 R13.1 R14.1 R142.2
POP_R: Q19.B R142.1
PROC_SEL_L: CPU.AB36 STP5.1
PROCHOT_L: CPU.C39 R258.2
PROCPWRGD: PCH1.AM3 R297.1
QN9TS_BLEED: QN3.1 R520.2
QN9TS_BLEED_D: QN3.3 R522.2
REGOUT_1: C178.1 R213.1 U19.24
RLAN_PWR_EN: D12.S PCH1.BD13 R375.1
RLAN_PWR_EN_R: D12.D R126.1 U15.3
RSMRST_L: C354.1 C528.1 PCH1.BA11 Q55.C R368.1 R537.1 U35.82
RSMRST_L1_1: Q61.B R564.2
RSMRST_L1_2: C565.1 Q55.B Q61.C R572.2
RSMRST_L1_3: C564.1 R562.2 R563.1 R564.1
RSTIN_L: R480.1 U35.128
RTCRST_L: C340.1 PCH1.BC10 R463.2
RTCX1_IN: C333.1 PCH1.BC9 R343.1 R344.1
RTCX1_IN_S: R343.2 Y2.1
RTCX2_OUT: C335.1 PCH1.BD10 R344.2 Y2.2
SATA3_RX_N0: C473.2 PCH1.G35
SATA3_RX_N1: C478.2 PCH1.D39
SATA3_RX_P0: C469.2 PCH1.E35
SATA3_RX_P1: C483.2 PCH1.E37
SATA3_TX_N0: C479.2 PCH1.C36
SATA3_TX_N1: C472.2 PCH1.B38
SATA3_TX_P0: C484.2 PCH1.B36
SATA3_TX_P1: C468.2 PCH1.C38
SATA3R_N0: C473.1 SATA1.5
SATA3R_N1: C478.1 SATA2.5
SATA3R_P0: C469.1 SATA1.6
SATA3R_P1: C483.1 SATA2.6
SATA3T_N0: C479.1 SATA1.3
SATA3T_N1: C472.1 SATA2.3
SATA3T_P0: C484.1 SATA1.2
SATA3T_P1: C468.1 SATA2.2
SATALED_L: PCH1.AD44 Q66.E R410.1 R560.1
SATALED_L_B: Q66.B R561.1
SDI: CODEC.8 R137.2
SENSE-A: CODEC.13 R114.1 R115.1 R116.1
SENSE-B: CODEC.34 R38.2 R39.2
SERIRQ: PCH1.BA17 R400.1 TCM.16 U35.36
SIO_24M: C560.1 R371.2 U35.44
SIO_CLKIN: C559.1 R372.2 U35.34
SIO_GND: C461.2 C470.2 C474.2 C481.2 C485.2 C489.2 C497.1 C504.2 C505.1 L31.2 R484.2 R493.2 R498.2 R508.2 R523.1 U35.83
SIO_GP16: R387.1 R474.1 U35.127
SIO_LED0: R556.2 R557.2 U35.11
SIO_LED0_R: Q64.B R556.1
SIO_LED1: R558.2 R559.1 U35.9
SIO_LED1_R: Q65.B R559.2
SIO_PECI: R231.2 R578.2
SIO_PECI_R: C561.1 R578.1 U35.51
SIO_PWRON_L: PCH1.AT13 R542.1 U35.69
SIO_VCC3: R515.1 U35.89
SIO_VCC3_1: Q63.D R601.2
SIO_VCORE: C551.1 C558.1 U35.33
SIO_VREF: C497.2 R516.1 U35.88
SLP_AMT_L: PCH1.BC15 STP30.1
SLP_LAN_L: PCH1.AV15 STP11.1
SLP_S0_L: PCH1.BC26 STP17.1
SLP_S3_L: D16.1 PCH1.AW15 R293.1 R464.1 U14.1 U27.5 U35.68 U37.1
SLP_S3_L_R: Q44.D Q45.S
SLP_S4_L: PCH1.BD15 Q51.G R315.2 R501.1 R549.2 U35.74
SLP_S4_L_R: Q59.G R549.1
SLP_S4_L_R_D: Q59.D Q64.E Q65.E R553.2
SLP_S4_L_REV: Q50.G Q51.D R520.1 R521.1
SLP_VCCST_S4: C303.1 R315.1 U24.3 U24.5
SLPSUS_L: PCH1.BB13 R434.1 R443.2 U35.3
SLS3_BF: Q30.D R277.1 R279.1 R282.1 R287.1 R304.1 R305.1
SLS3_BF_R1: Q28.B R287.2
SLS3_BF_R2: Q27.B R282.2
SLS3_BF_R3: Q29.B R304.2
SLS3_BF_R4: Q25.B Q26.B R277.2 R279.2
SLS3_BF_R5: C275.2 Q30.G R293.2
SLS3_BF_R6: Q29.C R303.1
SMB_STBY_MAIN_G: Q35.D Q38.G Q43.G R451.2
SMB_STBY_MAIN_G_G: Q35.G Q37.D R424.2
SMBALERT_L: PCH1.BB41 R427.1
SMBCLK_MAIN: Q38.S R35.2 R446.1 R447.1 R597.1 U4.30
SMBCLK_STBY: PCIE16X.B5 Q38.D R393.1 R405.1 R579.2
SMBCLK_STBY_IO: C562.2 R579.1 U35.60
SMBCLK_STBY_R: PCH1.AW44 R393.2
SMBDATA_MAIN: Q43.S R27.2 R455.1 R456.1 R595.1 U4.29
SMBDATA_STBY: PCIE16X.B6 Q43.D R394.1 R404.1 R580.2
SMBDATA_STBY_IO: C563.2 R580.1 U35.61
SMBDATA_STBY_R: PCH1.BB43 R394.2
SMCLK_DIMM: C401.1 DIMM1.141 DIMM2.141 R447.2
SMDATA_DIMM: C408.1 DIMM1.285 DIMM2.285 R455.2
SML0_CLK: PCH1.AY44 R426.1
SML0_DATA: PCH1.BB39 R425.1
SML0ALERT_L: PCH1.BA40 STP25.1
SML1_CLK: PCH1.AW42 R428.2 U35.28
SML1_DATA: PCH1.AW45 R406.2 U35.50
SML1ALERT_L: PCH1.AT27 R429.1 STP13.1
SPI0_IO2: PCH1.BC29 STP22.1
SPI0_IO3: PCH1.BD30 STP18.1
SPI_CLK: R383.1 SPIROM1.6
SPI_CS_L0: C396.1 PCH1.BD31 SPIROM1.1
SPI_IO2_0: SP19.2 SPIROM1.3
SPI_IO3_0: R449.2 SPIROM1.7
SPI_MISO: C391.1 R380.2 R381.1 SPIROM1.2
SPI_MISO_R: PCH1.BE30 R380.1
SPI_MOSI: C388.1 R377.2 R378.1 SPIROM1.5
SPI_MOSI_R: PCH1.BB29 R377.1
SPI_WP: Q42.E R438.1 R442.2 SP19.1
SRTCRST_L: C342.1 PCH1.BB10 R358.2
SUS_1P0A: Q84.5 Q84.6 R618.2
SUSACK_L: PCH1.BB19 R512.1 R513.2 R519.1
SUSACK_L_R: R519.2 U35.13
SUSCLK: PCH1.AN15 STP10.1
SUSWARN_L: PCH1.BD19 R511.1 R513.1 U35.12
SYS_THERM: C504.1 C505.2 R516.2 R523.2 U35.87
SYS_VSB: R546.1 U35.67
TCM_24M: C577.2 R365.2 R593.1 TCM.1
THERMAL_SD: PCH1.AE44 R409.1 U35.10
TP_CPU_K12: CPU.K12 STP3.1
TP_CPU_L12: CPU.L12 STP4.1
TP_FAN_CTL4: STP31.1 U35.118
TP_PCH_AB13: PCH1.AB13 STP9.1
TP_PWMOUT: R526.2 U35.15
TP_SPI1_CLK: PCH1.AN36 STP19.1
TP_SPI1_CS_N: PCH1.AL39 STP23.1
TP_SPI1_IO2: PCH1.AG44 STP29.1
TP_SPI1_IO3: PCH1.AH43 STP27.1
TP_SPI1_MISO: PCH1.AN38 STP21.1
TP_SPI1_MOSI: PCH1.AN41 STP26.1
TP_VGA: PCH1.L44 R396.2 STP_VGA.1
TPM_P5: C578.2 R594.1 TCM.5
TPM_P6: R595.2 R596.2 TCM.6
TPM_P15: R598.1 TCM.15
TPM_P18: R607.1 TCM.18
TPM_P19: R599.1 R600.1 TCM.19
TPM_RSV2: R597.2 TCM.20
TS_D-: SP20.1 U35.84
UGND: C90.1 C91.2 C94.1 C95.2 C96.1 C97.2 C102.2 C104.2 R61.1 R65.1 R108.1 U11.2 U12.2 USB2_LAN.G1 USB2_LAN.G2 USB2_LAN.G3 USB2_LAN.G4 USB2_LAN.G5 USB2_LAN.G6 USB2_LAN.G7 USB2_LAN.G8 USB2_LAN.U4 USB2_LAN.U8
UP1740P_FB: C492.1 R504.1 R510.2 U32.3
UP1740P_P1: C496.2 U32.1
UP1740P_P2: R514.1 U32.2
UP1740P_P7: R486.1 U32.7
UP1740P_P9: C467.2 R477.1 R481.2 U32.9
