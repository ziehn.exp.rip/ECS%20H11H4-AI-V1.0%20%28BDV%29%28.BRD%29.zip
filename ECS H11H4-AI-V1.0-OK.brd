# Allegro board ECS H11H4-AI-V1.0-OK.brd (continued)
## Nets (continued)
UP1740P_P10: C597.1 R481.1 U32.10
UP1740P_P13: C501.2 C512.2 C513.2 C514.2 L30.1 R486.2 U32.13 U32.23
UP1740P_P14: C524.1 U32.14
UP1740P_P16: R535.1 U32.16
UP1740P_P16_1: C524.2 R535.2
UP1740P_PHASE_S: C465.2 R489.1
UP1740P_VTTIN: C525.2 R532.1 U32.17
USB2_COMP: PCH1.AG3 R324.1
USB2_ID: PCH1.AG2 R323.1
USB2_VBUSSENSE: PCH1.AD10 R325.1
USB3_RX_N1: CHOKE14.1 PCH1.B7 RN14.1(A)
USB3_RX_N1_R: CHOKE14.2 RN14.2(B) U36.5 U36.6 USB3F.2
USB3_RX_N2: CHOKE13.1 PCH1.C8 RN14.5(A)
USB3_RX_N2_R: CHOKE13.2 RN14.6(B) U36.2 U36.9 USB3F.18
USB3_RX_N3: CHOKE5.1 PCH1.B10 RN6.1(A)
USB3_RX_N3_R: CHOKE5.2 RN6.2(B) U6.1 U6.10 USB3X2.14
USB3_RX_N4: CHOKE6.1 PCH1.E11 RN6.5(A)
USB3_RX_N4_R: CHOKE6.2 RN6.6(B) U6.4 U6.7 USB3X2.5
USB3_RX_P1: CHOKE14.4 PCH1.A7 RN14.3(A)
USB3_RX_P1_R: CHOKE14.3 RN14.4(B) U36.4 U36.7 USB3F.3
USB3_RX_P2: CHOKE13.4 PCH1.B8 RN14.7(A)
USB3_RX_P2_R: CHOKE13.3 RN14.8(B) U36.1 U36.10 USB3F.17
USB3_RX_P3: CHOKE5.4 PCH1.A9 RN6.3(A)
USB3_RX_P3_R: CHOKE5.3 RN6.4(B) U6.2 U6.9 USB3X2.15
USB3_RX_P4: CHOKE6.4 PCH1.G11 RN6.7(A)
USB3_RX_P4_R: CHOKE6.3 RN6.8(B) U6.5 U6.6 USB3X2.6
USB3_TX_N1: C509.1 PCH1.C11
USB3_TX_N1_C: C509.2 CHOKE12.1 RN13.1(A)
USB3_TX_N1_R: CHOKE12.2 RN13.2(B) U34.5 U34.6 USB3F.5
USB3_TX_N2: C498.1 PCH1.B12
USB3_TX_N2_C: C498.2 CHOKE11.1 RN13.5(A)
USB3_TX_N2_R: CHOKE11.2 RN13.6(B) U34.2 U34.9 USB3F.15
USB3_TX_N3: C79.1 PCH1.C13
USB3_TX_N3_C: C79.2 CHOKE8.1 RN7.5(A)
USB3_TX_N3_R: CHOKE8.2 RN7.6(B) U7.4 U7.7 USB3X2.17
USB3_TX_N4: C78.1 PCH1.A14
USB3_TX_N4_C: C78.2 CHOKE7.1 RN7.1(A)
USB3_TX_N4_R: CHOKE7.2 RN7.2(B) U7.1 U7.10 USB3X2.8
USB3_TX_P1: C500.1 PCH1.B11
USB3_TX_P1_C: C500.2 CHOKE12.4 RN13.3(A)
USB3_TX_P1_R: CHOKE12.3 RN13.4(B) U34.4 U34.7 USB3F.6
USB3_TX_P2: C493.1 PCH1.A12
USB3_TX_P2_C: C493.2 CHOKE11.4 RN13.7(A)
USB3_TX_P2_R: CHOKE11.3 RN13.8(B) U34.1 U34.10 USB3F.14
USB3_TX_P3: C80.1 PCH1.D13
USB3_TX_P3_C: C80.2 CHOKE8.4 RN7.7(A)
USB3_TX_P3_R: CHOKE8.3 RN7.8(B) U7.5 U7.6 USB3X2.18
USB3_TX_P4: C77.1 PCH1.B13
USB3_TX_P4_C: C77.2 CHOKE7.4 RN7.3(A)
USB3_TX_P4_R: CHOKE7.3 RN7.4(B) U7.2 U7.9 USB3X2.9
USB+5: L14.4 RN9.6(B) U13.4 USB2_LAN.U7
USB+6: L13.4 RN9.2(B) U13.6 USB2_LAN.U3
USB+7: F_USB.6 L27.4 RN11.6(B) U28.6
USB+8: F_USB.5 L26.4 RN11.2(B) U28.4
USB-5: L14.1 RN9.8(B) U13.3 USB2_LAN.U6
USB-6: L13.1 RN9.4(B) U13.1 USB2_LAN.U2
USB-7: F_USB.4 L27.1 RN11.8(B) U28.1
USB-8: F_USB.3 L26.1 RN11.4(B) U28.3
USB_EN: D20.3 R104.1 R460.2 R586.1 RJ4.2
USB_EN1: C575.1 R586.2 U27.4 U37.2
USB_EN2: C89.1 R104.2 U14.2
USB_H1: CHOKE10.3 RN8.8(B) U8.3 USB3X2.12
USB_H2: CHOKE9.3 RN8.4(B) U8.1 USB3X2.3
USB_L1: CHOKE10.2 RN8.6(B) U8.4 USB3X2.11
USB_L2: CHOKE9.2 RN8.2(B) U8.6 USB3X2.2
USB_N1: CHOKE10.1 PCH1.AF5 RN8.5(A)
USB_N2: CHOKE9.1 PCH1.AD5 RN8.1(A)
USB_N3: CMK1.4 PCH1.AG8 RN12.5(A)
USB_N3_R: CMK1.3 RN12.6(B) U30.4 USB3F.12
USB_N4: CMK2.4 PCH1.AE1 RN12.1(A)
USB_N4_R: CMK2.3 RN12.2(B) U30.1 USB3F.8
USB_N5: L14.2 PCH1.AC2 RN9.7(A)
USB_N6: L13.2 PCH1.AF2 RN9.3(A)
USB_N7: L27.2 PCH1.AB3 RN11.7(A)
USB_N8: L26.2 PCH1.AL8 RN11.3(A)
USB_OC2_L: PCH1.AD39 R390.1
USB_OC3_L: PCH1.AC44 STP24.1
USB_OC7_L: PCH1.W43 R392.1
USB_P1: CHOKE10.4 PCH1.AG7 RN8.7(A)
USB_P2: CHOKE9.4 PCH1.AD7 RN8.3(A)
USB_P3: CMK1.1 PCH1.AG10 RN12.7(A)
USB_P3_R: CMK1.2 RN12.8(B) U30.3 USB3F.11
USB_P4: CMK2.1 PCH1.AE2 RN12.3(A)
USB_P4_R: CMK2.2 RN12.4(B) U30.6 USB3F.9
USB_P5: L14.3 PCH1.AC3 RN9.5(A)
USB_P6: L13.3 PCH1.AF3 RN9.1(A)
USB_P7: L27.3 PCH1.AB2 RN11.5(A)
USB_P8: L26.3 PCH1.AL7 RN11.1(A)
VBOOT/ADDR: R51.2 R67.2 U10.28
VBOOT_V1P05_N1: Q8.D R51.1
VBOOTA/ADDRA: R68.2 U10.27
VCORE_GSENS: C111.1 CPU.D38 R132.1 R140.2 R141.1
VCORE_GT_GSENS: C130.1 CPU.F38 R159.1 R177.2
VCORE_GT_SENS: CPU.F39 R150.1 R160.1
VCORE_SENS: CPU.C38 R124.1 R132.2 R133.1
VGA_BLUE: C40.1 FB3.1 R17.1 U4.21
VGA_BLUE_CONN: C18.1 FB3.2 U1.3 VGA.3
VGA_DDCCLK_CNN: C22.1 R22.2 R32.2 U2.1 VGA.15
VGA_DDCSDA_CNN: C23.1 R21.2 R33.2 U2.3 VGA.12
VGA_GREEN: C39.1 FB2.1 R16.1 U4.22
VGA_GREEN_CONN: C17.1 FB2.2 U1.4 VGA.2
VGA_HSYNC: R30.1 U4.19
VGA_HSYNC_CNN: C20.1 R30.2 U2.6 VGA.13
VGA_RED: C38.1 FB1.1 R15.1 U4.23
VGA_RED_CONN: C25.1 FB1.2 U1.6 VGA.1
VGA_VSYNC: R31.1 U4.18
VGA_VSYNC_CNN: C21.1 R31.2 U2.4 VGA.14
VPP_PGOOD: STP32.1 U29.1
VR_ALERT: R147.1 U10.4
VR_COMP: C93.2 C103.2 U10.48
VR_COMP_R: C93.1 R113.2
VR_COMPA: C106.2 C109.2 U10.18
VR_COMPA_R: C106.1 R123.2
VR_CSCOMP: C87.1 C98.1 R100.1 R110.2 RT2.1 U10.47
VR_CSCOMP_NTC: R99.1 R100.2 RT2.2
VR_CSCOMPA: C100.1 C101.1 R106.1 R117.2 RT4.1 U10.19
VR_CSCOMPA_NTC: R102.1 R106.2 RT4.2
VR_CSN1: C62.2 R52.2 R59.2 SP6.2 U10.38
VR_CSN1A: C64.2 R56.2 R69.2 SP11.2 U10.26
VR_CSN2: C65.2 R62.2 R64.2 SP5.2 U10.40
VR_CSN2A: C84.2 R80.2 R98.2 SP13.2 U10.24
VR_CSN3: C81.2 R76.2 R84.2 SP8.2 U10.42
VR_CSP1: R57.2 R58.1 SP4.2
VR_CSP1_IC: C62.1 R52.1 R58.2 U10.39
VR_CSP1_R: R57.1 R63.2
VR_CSP1A: R70.1 R71.2 SP12.2
VR_CSP1A_IC: C64.1 R69.1 R70.2 U10.25
VR_CSP1A_R: R71.1 R112.2
VR_CSP2: R74.2 R75.1 SP3.2
VR_CSP2_IC: C65.1 R62.1 R75.2 U10.41
VR_CSP2_R: R73.2 R74.1
VR_CSP2A: R82.2 R97.1 SP14.2
VR_CSP2A_IC: C84.1 R86.1 R97.2 R98.1 U10.23
VR_CSP2A_R: R82.1 R87.2
VR_CSP3: R78.2 R92.1 SP9.2
VR_CSP3_IC: C81.1 R84.1 R85.1 R92.2 U10.43
VR_CSP3_R: R77.2 R78.1
VR_CSREF: C86.2 R59.1 R64.1 R76.1 U10.44
VR_CSREFA: C92.2 R56.1 R80.1 U10.22
VR_CSSUM: C87.2 C98.2 R63.1 R73.1 R77.1 R99.2 U10.45
VR_CSSUMA: C100.2 C101.2 R87.1 R102.2 R112.1 U10.21
VR_DIFF: R119.1 R125.1 U10.50
VR_DIFF_R: C107.1 R125.2
VR_DIFFA: R127.1 R139.1 U10.16
VR_DIFFA_R: C108.1 R127.2
VR_DRON: R178.1 R179.1 R264.1 R288.1 R347.1 U10.35
VR_DRON1: R179.2 U17.3
VR_DRON1A: R288.2 U23.3
VR_DRON2: R178.2 U16.3
VR_DRON2A: R347.2 U25.3
VR_DRON3: R264.2 U21.3
VR_EN_C1: Q21.D Q22.G R246.1
VR_EN_C2: Q23.G Q24.D R269.1
VR_ENABLE: C124.2 C265.2 Q28.C R144.2 R163.1 R251.2 R252.1 R479.2 U10.2 U18.6
VR_FB: C103.1 C107.2 R113.1 R118.2 R119.2 U10.49
VR_FBA: C108.2 C109.1 R123.1 R128.2 R139.2 U10.17
VR_HOT_L: C233.1 R157.1 R258.1 R259.2 U10.12
VR_ILIM: R110.1 U10.46
VR_ILMA: R117.1 U10.20
VR_IMAX: R55.2 U10.36
VR_IMAXA: R66.2 U10.29
VR_IOUT: C123.2 R145.2 U10.1
VR_IOUTA: C128.2 R158.2 U10.13
VR_PROG2: R143.2 U10.10
VR_PWM1: U10.34 U17.2
VR_PWM1_BST: R183.1 U17.1
VR_PWM1_BST_R: C167.2 R183.2
VR_PWM1_HG: R197.1 U17.8
VR_PWM1_HG_R: QCH1.G R197.2 R199.2
VR_PWM1_LG: R192.1 U17.5
VR_PWM1_LG_R: QCL1.G QCL4.G R192.2
VR_PWM1_VCC: C156.2 R184.1 U17.4
VR_PWM1A: U10.30 U23.2
VR_PWM1A_BST: R285.1 U23.1
VR_PWM1A_BST_R: C260.2 R285.2
VR_PWM1A_HG: R280.1 U23.8
VR_PWM1A_HG_R: QCGH1.G R278.2 R280.2
VR_PWM1A_LG: R268.1 U23.5
VR_PWM1A_LG_R: QCGL1.G QCGL3.G R268.2
VR_PWM1A_VCC: C262.2 R286.1 U23.4
VR_PWM2: U10.33 U16.2
VR_PWM2_BST: R182.1 U16.1
VR_PWM2_BST_R: C166.2 R182.2
VR_PWM2_HG: R196.1 U16.8
VR_PWM2_HG_R: QCH2.G R196.2 R198.2
VR_PWM2_LG: R218.1 U16.5
VR_PWM2_LG_R: QCL2.G QCL5.G R218.2
VR_PWM2_VCC: C153.2 R181.1 U16.4
VR_PWM2A: U10.31 U25.2
VR_PWM2A_BST: R348.1 U25.1
VR_PWM2A_BST_R: C337.2 R348.2
VR_PWM2A_HG: R332.1 U25.8
VR_PWM2A_HG_R: QCGH2.G R328.2 R332.2
VR_PWM2A_LG: R340.1 U25.5
VR_PWM2A_LG_R: QCGL2.G QCGL4.G R340.2
VR_PWM2A_VCC: C336.2 R345.1 U25.4
VR_PWM3: U10.32 U21.2
VR_PWM3_BST: R255.1 U21.1
VR_PWM3_BST_R: C228.2 R255.2
VR_PWM3_HG: R245.1 U21.8
VR_PWM3_HG_R: QCH3.G R243.2 R245.2
VR_PWM3_LG: R240.1 U21.5
VR_PWM3_LG_R: QCL3.G QCL6.G R240.2
VR_PWM3_VCC: C231.2 R265.1 U21.4
VR_READY: C125.2 Q27.C R167.1 R173.2 R341.1 U10.6
VR_ROSC: R149.2 U10.8
VR_SCLK: R148.1 U10.5
VR_SDIO: R146.1 U10.3
VR_TSENSE: C63.1 R54.2 U10.37
VR_TSENSE_NTC: R53.2 R54.1 RT1.2
VR_TSENSEA: C127.1 R156.2 U10.11
VR_TSENSEA_NTC: R156.1 R176.2 RT3.2
VR_VCC: C131.2 R175.1 U10.7
VR_VRAMP: C126.1 R161.2 R162.1 U10.9
VR_VSN: C116.2 R141.2 U10.52
VR_VSNA: C129.2 R159.2 U10.14
VR_VSP: C111.2 R133.2 U10.51
VR_VSPA: C130.2 R150.2 U10.15
VRALERT_L: PCH1.BD23 R386.1
VRD_C1: C332.2 Q32.G R341.2
VRD_C2: Q31.G Q32.D R342.2
VRD_C4_1: Q31.D R316.1 R317.1 R319.2
VRD_THERMDA: C140.1 C506.1 Q20.B Q20.C U35.86
VRD_THERMDC: C140.2 C506.2 Q20.E SP20.2
VREF: C34.1 CODEC.27
VSA_GSENS: SP1.1 SP7.1 SP15.1
VSA_PWRGD: R173.1 U18.8
VSA_SENS: CPU.AD5 SP2.1
VTT_EN: D16.3 R357.2 R495.1
VTT_EN_N1: QN1.D QN2.1 R355.2
VTT_EN_N2: C341.2 QN1.G R349.2
WAKE_L: R225.2 R226.1 U19.21
WRST_L: C569.1 R575.1 U35.47
XCLK_BIASREF: PCH1.E1 R327.2
XTAL1: C161.1 U19.28 Y1.2
XTAL2: C160.1 U19.29 Y1.1
XTAL_24M_IN: C331.1 PCH1.A6 R339.1 X1.2
XTAL_24M_OUT: C328.1 PCH1.A5 R339.2 X1.1
N18066055: C99.2 F_AUDIO.4 R122.1
N18833916: F_PANEL.7 R591.2 R592.1
N18839810: D23.P U33.10
N32097828: R28.1 U4.11
N32097831: TP2.1 U4.12
N32097834: TP1.1 U4.13
N32111832: C307.1 U24.12
N32111846: C306.1 U24.10
N32196073: C547.2 C548.2 C549.2 C585.1 EC25.1 FB5.2 FB6.2 FB7.2 QD5H1.D1 QD5H1.D2 QD5H1.D3 QD5H1.D4 QD5H1.D5
N32196079: C590.1 R611.2
N32196301: C587.1 D27.N R583.2
N32196344: C591.1 R584.2
N32208973: C175.2 C176.2 C177.2 C179.2 PFB2.1 R174.2 U18.13 U18.23
N32209107: R174.1 U18.7
N32209109: L19.1 R208.2 U18.12
N32209152: C174.2 R208.1
N32209166: C157.2 R189.2
N32209168: R189.1 U18.16
N32209170: C157.1 U18.14
N32209174: C144.1 R168.2 R171.1 U18.3
N32209188: C139.2 C144.2 R169.1 R171.2 SP2.2
N32209268: C154.2 R187.1 R188.2 U18.9
N32209303: R188.1 U18.10
N32209429: C145.2 U18.1
N32212142: C235.2 U22.1
N32212212: C249.2 C250.2 C251.2 C252.2 PFB4.1 R253.2 U22.13 U22.23
N32212317: R253.1 U22.7
N32212346: L22.1 R276.2 U22.12
N32212362: C243.2 R276.1
N32212384: C244.2 R272.2
N32212394: R272.1 U22.16
N32212396: C244.1 U22.14
N32212408: C230.1 R248.1 R254.2 U22.3
N32212414: C220.2 C230.2 R248.2 R249.1 SP10.2
N32212486: C239.2 R263.1 R271.2 U22.9
N32212535: R271.1 U22.10
N32215527: L29.1 R489.2 U32.12
N32228802: C477.2 R496.2 R497.2 U29.7
N32242153: C502.2 U31.1
N32242206: C499.2 C510.2 EC23.1 PFB5.1 R483.2 U31.13 U31.23
N32242332: R483.1 U31.7
N32242353: L28.1 R488.2 U31.12
N32242377: C462.2 R488.1
N32242399: C508.2 R525.2
N32242401: R525.1 U31.16
N32242403: C508.1 U31.14
N32242415: C490.1 R490.2 R503.1 U31.3
N32242493: C463.2 R468.1 R476.2 U31.9
N32242529: R476.1 U31.10
N32312087: Q86.5 QN5.C R554.2
N32312093: C592.1 QN5.B R565.2 R566.1
N32396708: C417.1 D20.2 R458.2
N32956468: C162.1 R190.1 R191.2 U39.24
N32957662: C190.1 L20.1 R195.1 U39.8 U39.9 U39.10 U39.16 U39.26
N32978550: C197.2 C198.2 C205.2 C593.2 PFB3.1 U39.3 U39.17 U39.18 U39.19 U39.20 U39.21 U39.25
N32999311: C190.2 R212.2
N32999325: R212.1 U39.22
N33018129: R195.2 U39.23
N33074508: C164.2 R180.1 U39.2
N33244839: C168.2 R194.2 R200.1 U39.5
N33303939: Q86.2 R616.2
N33304168: C594.2 Q84.2 R617.2 R620.1
N33306621: Q60.S Q85.S
N33351619: C598.1 R623.2
N33352335: R624.2 R625.2 U38.9

Pads without a net: ATX_POWER 7; BIOS_WP 1; CODEC 2 18 19 20 31 33 37 43 44 45 46 48; CPU 1 2 3 4 5 6 7 8 9 10 11 12 13 14 15 16 A12 A18 A23 AB37 AB38 AC37 AJ24 AJ25 AJ26 AJ27 AJ28 AJ29 AJ30 AK21 AK22 AK27 AL15 AM15 AN17 AN20 AN21 AP15 AP19 AP20 AT16 AU9 AU10 AU12 AU16 AU29 AU39 AU40 AV1 AV10 AV13 AV16 AV24 AV25 AV39 AW2 AW16 AW29 AW38 AY10 B11 B12 B18 B23 B39 C9 C11 C19 C23 C40 D9 D10 D12 D14 D15 D16 D17 D18 D19 D20 D23 E10 E12 E14 E18 E20 F9 F14 F17 F18 F20 F21 F35 F36 F37 G9 G10 G14 G16 G18 G20 G34 G35 H10 H11 H12 H14 H17 H19 H33 H34 J7 J8 J13 J14 J15 J17 J19 J33 J35 K8 K10 K11 K32 K34 L8 L10 L31 L33 M32; DIMM1 1 8 19 30 41 52 93 100 111 122 133 144 145 205 227 230 234 235 237 238; DIMM2 1 8 19 30 41 52 93 100 111 122 133 144 145 205 227 230 234 235 237 238; F_PANEL 9 13; F_USB 10; HDMI 13 14; ME_DISABLE 1; PCH1 A16 A21 A23 A35 A39 A40 A41 AA1 AA2 AA44 AA45 AB33 AB35 AB36 AB39 AB41 AB42 AB43 AB44 AC43 AD2 AD3 AD38 AE17 AE45 AF17 AF41 AG14 AG15 AG42 AG43 AH44 AJ7 AJ8 AJ11 AJ13 AJ33 AJ35 AJ38 AJ39 AJ42 AJ43 AJ44 AK44 AK45 AL27 AL35 AL36 AL42 AL43 AL44 AM43 AN17 AN24 AN29 AN42 AN43 AN44 AR17 AR19 AR22 AR24 AR27 AR29 AR31 AR38 AR39 AR41 AR44 AR45 AT33 AT42 AT43 AT44 AU41 AU43 AU44 AV2 AV3 AV29 AV43 AV44 AW2 AW24 AW27 AW33 AW35 B14 B15 B16 B19 B20 B21 B22 B24 B31 B32 B33 B35 B39 BA33 BA35 BA41 BB3 BB17 BB22 BB24 BB31 BB33 BB36 BB38 BC8 BC19 BC22 BC23 BC24 BC27 BC32 BC33 BC35 BC38 BD1 BD14 BD18 BD21 BD22 BD24 BD25 BD27 BD33 BD34 BD36 BD38 BE2 BE21 BE25 BE39 C1 C14 C15 C19 C20 C22 C24 C31 C32 C33 D1 D5 D7 D8 D22 D43 E5 E6 E17 E20 E22 E29 E41 E42 E45 F41 F45 G4 G13 G15 G17 G19 G22 G29 G31 G33 G37 G44 G45 H13 H15 H31 H33 H40 H42 H43 H44 J45 K13 K15 K17 K19 K24 K31 K37 K44 L5 L7 L17 L19 L24 L31 L37 L39 L43 M44 M45 N2 N3 N7 N8 N29 N31 N38 N39 N42 N43 N44 P1 P2 P3 P24 P27 P29 P31 P43 P44 R2 R3 R4 R7 R8 R11 R13 R24 R27 R35 R39 R42 R43 R44 T44 T45 U2 U3 U5 U7 U13 U35 U36 U39 U41 U42 U43 V1 V2 V44 W2 W3 W7 W13 W35 W36 W42 Y5; PCIE16X A5 A6 A7 A8 A19 A32 A33 A50 B9 B12 B30 B82; PSKM 2 6 8 12; TCM 13 14; U1 1; U4 27 28 31; U9 6; U15 4; U18 15; U22 15; U26 1; U27 6; U31 8 15; U32 15; U35 7 8 17 18 19 20 23 24 25 26 52 53 54 55 56 57 58 59 62 63 81 85 97 98 99 100; U37 6; U39 7; USB3F 10; VGA 4 11

## Via types
v1: diameter 0.559, hole 0.279, TOP to BOTTOM, 132 vias
v2: diameter 0.61, hole 0.305, TOP to BOTTOM, 2544 vias
v3: diameter 0.762, hole 0.381, TOP to BOTTOM, 306 vias
v4: diameter 0.508, hole 0.254, TOP to BOTTOM, 711 vias
v5: diameter 1.016, hole 0.508, TOP to BOTTOM, 72 vias
v6: diameter 0.457, hole 0.254, TOP to BOTTOM, 36 vias
v7: diameter 0.559, hole 0.305, TOP to BOTTOM, 490 vias
v8: diameter 0.762, hole 0.406, TOP to BOTTOM, 12 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
3VR_GO: length 5.1
  TOP w0.102: C214.2 9.34,145.13 Q21.G v1(8.55,147.08) ; C214.2 R242.2 ; C214.2 R244.1
3VSBSW_L: length 47.2
  TOP w0.102: v2(179.71,23.75) 180.47,23.75 183.04,21.19 184.1,21.19 184.61,21.7 U35.76 ; v2(146.91,21.12) R536.1 R527.2
  BOTTOM w0.102: v2(146.91,21.12) 146.91,20.46 150.9,16.46 164,16.46 165.13,17.6 166.6,17.6 170.05,21.05 173.61,21.05 175.62,23.06 v3(176.86,23.06) 177.56,23.75 v2(179.71,23.75)
5VD_C1: length 5.1
  TOP w0.102: C529.2 144.3,20.14 v2(143.99,20.44)
  TOP w0.254: R536.2 144.85,20.17 C529.2 144.82,19.87 144.39,19.44 Q54.B
  BOTTOM w0.102: v3(144.86,20.59) 144.15,20.59 v2(143.99,20.44)
5VD_C2: length 11.4
  TOP w0.102: v1(139.95,21.05) 139.74,20.83 R541.2
  TOP w0.254: Q54.C 140.37,20.45 140.09,20.17 R541.2 139.61,20.17 R540.1 138.04,18.6 136.04,18.6 133.71,16.26 R548.2 R551.2
5VD_C3: length 2.8
  TOP w0.102: R540.2 v1(138.66,21.07)
  TOP w0.254: R540.2 137.55,20.17 137.33,19.94 Q53.B
5VD_C3_1: length 3.6
  TOP w0.102: v2(132.03,15.28) 132.37,14.94 Q62.B
  TOP w0.254: Q62.B 133.01,14.23 133.23,14.01 R551.1
  BOTTOM w0.102: v3(132.84,15.72) 132.46,15.72 v2(132.03,15.28)
5VDAUL_CT3: length 3.1
  TOP w0.102: R517.2 v1(25.81,25.75)
  TOP w0.254: R517.2 R507.2 R506.1
5VDAUL_CT3_1: length 4.2
  TOP w0.254: R517.1 29.66,24.8 30.07,25.22 Q52.G
5VDAUL_CT3_2: length 5.3
  TOP w0.102: R507.1 v1(26.71,28.77)
  TOP w0.254: R507.1 27.38,27.85 28.04,28.52 29.24,28.52 30.07,29.36 Q49.G
5VDAUL_CT3_3: length 2.5
  TOP w0.254: R533.2 29.12,22.14 R529.2 29.03,23.53 Q52.D
5VDAUL_CT3_4: length 4
  TOP w0.254: Q57.G 28.07,19.88 C532.1 29.34,20.39 29.03,20.71 C527.2 29.06,21.18 R533.1
5VDAUL_CT3_5: length 4
  TOP w0.254: Q45.D 27.03,30.5 v1(26.59,30.07) 26.59,29.96 R492.2 R506.2
5VDAUL_CT3_6: length 1.4
  TOP w0.102: R464.2 24.07,40.87 24.23,40.71 Q44.G
5VDAUL_CT7: length 31.4
  TOP w0.102: Q85.G 32.66,16.71 30.33,16.71 Q60.G 29.57,14.5 29.36,14.29 27.66,14.29 27.28,14.67 27.28,15.06 26.14,16.2 26.14,17.95 27.18,18.99 31.47,18.99 31.64,19.17 31.64,19.66 31.24,20.06 30.99,20.06 30.84,20.21 30.84,21.75 C536.1
  TOP w0.254: Q49.D v2(30.26,27.44) 30.9,26.8 30.9,26.1 31.5,25.5 R530.2 30.84,24.45 30.07,23.69 30.07,23.06 30.8,22.33 C536.1
  BOTTOM w0.102: v3(30.26,28.28) v2(30.26,27.44)
5VDLA: length 18
  TOP w0.254: v2(131.08,15.3) 130.14,15.3 Q62.C 130.09,13.44 C566.1 131.13,12.39 132.21,12.39 R568.2 ; v2(126.98,15.18) 126.42,15.74 123.44,15.74 123.06,16.12 121.84,16.12 121.51,16.45 121.51,17.4 121.75,17.64 QN4.3
  BOTTOM w0.254: v2(131.08,15.3) 128.93,15.3 v3(128.73,15.5) 127.29,15.5 v2(126.98,15.18)
5VDLSB: length 11.1
  TOP w0.254: Q53.C 135.04,19.69 134.5,19.15 C540.2 R543.2 132.59,19.18 C539.1 130.88,18.55 129.83,18.55 v1(129.67,18.38) 129.07,17.79 126.85,17.79 126.47,17.4 Q56.G
12VR_GO: length 8.4
  TOP w0.102: v1(5.36,132.73) 5.36,132.5 5.84,132.02 Q24.G 7.53,133.04 8.36,133.04 9.31,133.99 C240.2 9.98,132.59 R274.1 R275.2
+1V05_SA: length 48
  TOP w0.203: v2(104.05,167.9) 103.85,167.69 U18.2
  TOP w0.254: R169.2 107.42,171.27 107.93,170.76 v2(107.93,168.22)
  TOP w0.305: v7(111.48,114.47) CPU.Y8 ; v7(110.39,118.76) CPU.R7 ; CPU.N7 v7(110.39,120.59)
  TOP w0.356: v7(110.39,120.59) CPU.P7 ; v7(109.47,116.02) CPU.W7 ; CPU.Y6 v7(109.47,115.11) CPU.Y7 ; CPU.T7 v7(110.39,118.76)
  TOP w0.381: v7(110.39,117.85) CPU.U7 ; CPU.V7 v7(109.47,116.02)
  BOTTOM w0.254: v2(107.93,168.22) 112.18,163.96 112.18,152.66 v2(111.54,152.02)
  BOTTOM w0.508: 102.31,152.68 100.37,154.62 100.37,165.99 101.45,167.07 103.23,167.07 v2(104.05,167.9)
  vias: v2(105.32,149.29) v2(105.83,153.29) v2(106.08,151.83) v2(107.1,150.88) v2(108.12,149.29) v2(108.12,147.58) v2(108.81,150.95) v2(109.39,153.42) v2(109.51,152.09) v2(111.29,149.48) v2(114.05,116.86) v2(114.02,115.89) v2(114.02,114.88) v2(114.02,113.1) v2(114.72,144.6) v2(116.69,142.44) v5(118.59,139.58) v5(121.96,136.34) v7(109.47,114.22) v7(110.39,114.22) v7(112.29,113.05) v7(112.37,113.99)
+2V5_DDRVPP: length 51.6
  TOP w0.508: R487.2 v2(138.82,31.15) ; 94.18,30.96 C477.1 R497.1
  BOTTOM w0.508: v2(138.82,31.15) 138.82,32.42 138.25,32.99 137.34,32.99 136.49,32.14 133.57,32.14 132.3,33.41 119.1,33.41 117.51,34.99 101.51,34.99 97.45,30.93 v2(95.03,30.93)
+3VSB: length 551.8
  TOP w0.203: 28.73,49.84 29.31,49.26 29.31,42.84 29.57,42.58 29.57,40.62 29.62,40.57 29.62,37.34 29.31,37.03 29.31,35 28.78,34.48 28.78,32.91 28.58,32.71 27.56,32.71 27.23,33.04 27.23,34.46 25.38,36.31 25.38,37.89 24.21,39.06 22.78,39.06 22.45,38.73 22.45,36.95 25.25,34.16 25.25,31.13 25.63,30.75 R492.1 ; PCH1.AN5 43.14,97.96 v4(43.1,97.92) ; v4(40.2,91.4) PCH1.BA20
  TOP w0.254: PCH1.AJ41 45.45,80.62 v4(45.31,80.62) 44.98,80.29 PCH1.AL41 ; R598.2 136.63,7.85 136.63,7.18 137.01,6.8 137.01,5.02 137.52,4.51 138.91,4.51 139.32,4.92 139.32,7.23 139.04,7.51 139.04,8.23 R599.2 ; R398.2 26.61,72.36 26.31,72.66 v2(26.31,73.09) ; v2(40.93,108.46) C316.1 ; v2(26.58,79.34) 26.8,79.12 C358.1 ; PCH1.AD41 v4(47.59,80.59) ; 28.73,49.84 v2(28.87,49.98) ; R526.1 v2(161.9,23.82)
  TOP w0.381: R390.2 v2(47.6,70.83) ; v2(29.34,74.75) R381.2 R378.2 ; R428.1 41.82,67.35 R406.1 ; R386.2 29.31,71.95 v2(28.8,71.44) ; R391.2 v2(49.06,70.74) 49,70.68 R411.2 ; C373.1 46.36,73.27 v2(46.28,73.35) ; v2(26.7,64.38) 26.02,65.06 R431.2 ; v2(45.7,66.69) 45.93,66.46 R422.2 ; v2(26.01,88.21) 25.38,88.21 24.21,89.38 SP18.2 ; R392.2 50.65,70.81 v2(50.6,70.76) ; R423.2 49.95,67.41 R424.1 v2(50.08,68.14) R412.2 ; R384.2 v2(21.31,73.79)
  TOP w0.508: v2(195.24,35.69) 194.98,35.95 185.46,35.95 184.38,34.87 184.38,33.79 183.24,32.64 182.16,32.64 180.71,34.09 167.22,34.09 166.63,33.5 R474.2 165.39,33.15 163.36,31.12 ; R305.2 v2(10.95,112.21) ; v2(197.97,39.19) 199.04,40.25 199.04,81.46 R359.1 R357.1 R355.1 193.46,91.26 194.09,91.89 194.09,93.22 193.11,94.21 R351.2 190.79,95.16 R350.1 ; R546.2 190.35,17.6 v2(190.6,17.34) ; 163.36,31.12 163.36,28.8 R505.2 161.9,27.34 v2(161.9,26.87) ; 163.36,31.12 158.33,31.12 156.55,32.9 v2(153.14,32.9) 151.39,34.64 R470.2 R469.2 ; 11.67,155.56 C201.1 ; 11.67,155.56 11.33,155.56 v2(10.14,154.36) 10.14,153.87 11.6,152.41 11.6,143.08 v2(10.89,142.37) R246.2 ; 11.67,155.56 PCIE16X.B10 ; R306.1 C292.2 38.81,113.83 v2(38.33,114.31) ; R598.2 C581.1 134.66,10 135.48,10.83 135.48,13.4 134.72,14.17 134.72,16.56 136.25,18.09 138.61,18.09 R541.1 141.61,19.21 142.15,19.75 142.15,22.04 142.55,22.44 144.74,22.44 v2(145.24,22.93) 145.52,23.21 R527.1 R521.2 ; R152.1 36.52,174.28 Q13.E 35.34,175.46 32.96,175.46 32.13,174.62 v2(32.13,173.5) ; R537.2 191.49,19.63 v2(191.81,19.31) ; R425.2 R426.2 v2(38.96,66.27) R427.2 R428.1 41.31,65.7 43.31,65.7 44.04,66.44 v2(44.04,68.14) 44.23,68.33 R407.2 ; R269.2 v2(10.93,135.93) ; v2(28.82,65.79) RJ6.1 RJ5.1 RJ7.1 31.79,66.67 32.28,66.17 R430.2 R421.1 ; R342.1 7.94,99.29 v2(9.12,100.46) ; R512.2 163.9,26.71 v2(164.06,26.87) 164.25,27.06 R511.2 ; v2(25.96,173.5) 25.38,172.92 21.97,172.92 21.59,173.3 RJ1.1 20.99,172.29 v2(20.7,172) ; v2(43.89,74.44) 42.9,73.45 C371.1 43.85,71.6 R388.2 R389.2
  BOTTOM w0.254: v4(43.1,97.92) 42.58,98.44 42.58,106.81 v2(40.93,108.46) ; v2(161.9,26.87) v2(161.9,23.82) ; v2(26.58,79.34) 26.58,79.94 26.96,80.32 26.96,82.24 29.06,84.33 30.62,84.33 36.4,90.11 37.54,90.11 38.56,91.13 39.92,91.13 v4(40.2,91.4)
  BOTTOM w0.381: v4(47.59,80.59) 47.14,80.14 47.14,77.62 47.6,77.16 47.6,75.63 46.28,74.31 v2(46.28,73.35) ; v4(45.31,80.62) 45.31,80.2 44.43,79.32 44.43,76.27 43.89,75.74 v2(43.89,74.44)
  BOTTOM w0.508: v2(10.89,142.37) 10.89,142.02 10.93,141.99 v2(10.93,135.93) 10.2,135.2 10.2,123.7 10.01,123.51 10.01,119.2 11.41,117.8 11.41,112.67 v2(10.95,112.21) 10.51,112.21 9.91,111.61 9.91,110.49 10.26,110.13 10.26,105.35 9.44,104.53 9.44,100.78 v2(9.12,100.46) 8.93,100.27 8.93,94.87 v2(9.63,94.18) ; v2(164.06,26.87) v2(161.9,26.87) 159.42,26.87 156.92,24.36 146.67,24.36 v2(145.24,22.93) ; v2(49.06,70.74) 49.06,69.16 v2(50.08,68.14) ; v2(49.06,70.74) 50.58,70.74 v2(50.6,70.76) ; v2(49.06,70.74) 48.97,70.83 v2(47.6,70.83) ; v2(190.6,17.34) 191.81,18.55 v2(191.81,19.31) 195.24,22.74 v2(195.24,35.69) 195.24,36.45 v2(197.97,39.19) ; v2(153.14,32.9) 152.67,33.36 147.95,33.36 139.09,24.5 136.04,24.5 133.5,21.96 129.01,21.96 128.38,21.33 125.06,21.33 124.3,20.57 120.83,20.57 119.48,21.91 115.8,21.91 110.95,26.76 108.59,26.76 106.59,28.76 v2(106.59,31.63) ; v2(47.6,70.83) 45.64,68.88 44.78,68.88 v2(44.04,68.14) 45.49,66.69 v2(45.7,66.69) ; v2(47.6,70.83) 47.6,72.03 v2(46.28,73.35) ; v2(20.7,172) 19.85,172.85 18.53,172.85 17.31,171.63 17.31,168.6 14.71,165.99 13.31,165.99 11.02,163.71 11.02,162.17 10.14,161.28 v2(10.14,154.36) ; v2(38.96,66.27) 39.22,66.27 39.8,66.85 v2(39.8,68.19) ; v2(25.96,173.5) v2(32.13,173.5)
  vias: v2(27.03,49.98) v2(37.31,68.97) v2(105.77,32.45) v2(105.77,31.63) v2(106.53,32.45) v5(47.85,42.49) v5(47.85,41.22) v8(26.33,56.2) v8(26.33,55.25)
+5V_HDMI: length 45.9
  TOP w0.254: 157.73,201.7 HDMI.18
  TOP w0.508: v2(136.25,187.49) R72.1 R60.1 ; U9.5 141.01,189.46 C57.1 v2(139.74,189.62)
  BOTTOM w0.508: v2(169.33,202.06) 164.82,197.55 149.64,197.55 141.71,189.62 v2(139.74,189.62) 138.37,189.62 v3(137.52,188.76) v2(136.25,187.49)
+5VA: length 2.8
  TOP w0.254: 13.31,187.14 13.54,186.91 CODEC.38 ; C61.1 12.14,189.39 C58.1
  vias: v2(13.18,189.93) v2(13.18,189.05) v2(13.18,188.22) v2(22.9,191.78) v2(23.72,191.78) v2(23.66,190.95) v3(14.61,189.53)
+5VDUAL_1P0A: length 86.8
  TOP w0.203: v2(46.39,35.06) 46.39,36.58 43.41,39.57 30.33,39.57 29.95,39.19 29.95,37.21 29.69,36.95 29.69,34.92 29.11,34.33 29.11,32.66 28.8,32.35 27.33,32.35 26.77,32.91 26.77,34.44 24.71,36.49 24.71,37.69 23.9,38.5 v2(23.57,38.5)
  TOP w0.254: v2(21.26,32.81) 21.26,33.14 18.43,35.97 18.43,36.5 18.19,36.74 R619.1 16.8,35.79 R617.1
  TOP w0.508: PFB5.2 32.23,20.77 32.49,21.02 C537.2 33.38,22.33 34.14,23.08 34.14,24.96 31.22,27.88 v2(31.22,29.79) ; R468.2 v2(46.39,35.06)
  BOTTOM w0.254: v2(21.26,32.81) 21.26,32.84 21.57,33.14 21.57,33.93 23.57,35.93 v2(23.57,38.5)
  BOTTOM w0.508: v2(46.39,35.06) 45,36.45 v3(44.15,36.45) 32.8,36.45 29.12,32.77 29.12,30.63 29.96,29.79 v2(31.22,29.79)
+5VSB: length 617
  TOP w0.152: v2(48.68,115.5) 50.72,117.54 53.82,117.54 55.66,119.39 59.28,119.39 61.38,117.29 61.38,116.24 60.78,115.64 60.78,113.9 61.71,112.97 62.48,112.97 63.04,113.53 C296.2 63.32,113.53 63.91,114.12 U24.4
  TOP w0.254: R554.1 v2(66.21,13.66)
  TOP w0.457: 14.77,46.81 14.33,47.24 U27.2
  TOP w0.508: RJ4.1 17.31,12.02 16.59,12.74 ; R622.1 63.54,7.31 63.98,7.31 65.71,5.58 v2(66.22,5.58) ; v2(115.29,6.17) 115.29,6.93 114.88,7.34 R606.2 ; R572.1 195.36,9.47 194.67,8.77 v2(191.43,8.77) 190.73,9.47 190.73,12.01 191.05,12.32 R562.1 ; v2(65.76,3.7) 65.63,3.57 65.63,1.35 ; 115.86,2.1 116.87,1.09 191.37,1.09 v2(191.75,1.47)
  TOP w1.016: v5(4.48,73.22) 4.48,56.65 8.8,52.33 8.84,52.33 8.94,52.23 15.13,52.23 17.86,49.49 17.86,47.43 17.23,46.81 ; 95.48,4.07 v2(95.48,9.91) 95.48,14.86 Q58.D ; 95.48,4.07 97.96,1.59 115.35,1.59 115.86,2.1 v5(115.86,3.24) ; 95.48,4.07 92.76,1.35 14.7,1.35 13.75,2.29 13.75,11.18 15.31,12.74 16.59,12.74 17.95,14.1 v5(19.85,14.1) ; C118.1 95.32,174.99 90.96,170.63 84.74,170.63 70.26,156.15 64.9,156.15 61.28,152.53 51.41,152.53 47.86,148.98 v2(47.28,148.98) 29.71,148.98 25.96,152.72 22.99,152.72 21.84,153.87 v5(21.84,154.6) ; 14.77,46.81 17.23,46.81 ; 17.23,46.81 17.23,46.69 17.86,46.06 17.86,38.68 19.41,37.13 19.41,36.11 22.35,33.17 22.35,24.94 25.69,21.6
  BOTTOM w0.152: v2(48.68,115.5) 45.06,119.12 v3(45.06,145.93) 45.06,146.75 v2(47.28,148.98)
  BOTTOM w0.254: v2(66.21,13.66) 68.02,11.85 69.09,11.85 70.84,10.1 82.1,10.1 82.82,9.39 94.95,9.39 v2(95.48,9.91)
  BOTTOM w0.508: v2(66.22,5.58) 65.76,5.12 v2(65.76,3.7) ; v2(191.75,1.47) 191.43,1.78 v2(191.43,8.77)
  BOTTOM w1.016: v5(4.48,73.22) 5.37,73.22 6.64,74.49 6.64,76.6 4.81,78.43 3,80.24 3,149.71 6.39,153.1 10.26,153.1 11.09,153.93 11.09,160.98 11.98,161.87 11.98,163.33 13.75,165.11 15.08,165.11 16.54,166.57 21.31,166.57 21.87,166.01 21.87,154.63 v5(21.84,154.6) ; v5(19.85,14.1) v5(26.39,14.1)
  vias: v2(132.06,5.4) v2(134.21,5.4)
+12V: length 235.2
  TOP w0.254: R451.1 51.52,55.92 50.22,54.62 50.03,54.62 49.51,54.09 49.51,52.71 48.81,52.01 45.95,52.01 44.43,53.54 35.28,53.54 v2(35.15,53.66) ; R91.2 C83.1 127.96,182.66 127.23,181.93 124.5,181.93 123.17,183.27 103.23,183.27 102.47,182.51 102.47,180.02 91.69,169.23 85.32,169.23 70.72,154.63 65.35,154.63 61.77,151.04 53.28,151.04 51.66,149.42 50.57,149.42 v2(50.11,149.88) ; D22.P C480.1 v2(148.31,29.06) ; v2(26.39,46.93) 26.77,46.93 27.58,46.12 27.58,39.7 v2(26.96,39.08) ; R485.1 196.06,30.55 v2(196.19,30.68) ; v2(5.44,131.51) 5.82,131.13 9.53,131.13 R274.2
  TOP w0.508: v2(134.47,13.02) 134.34,12.9 R568.1 ; 67.06,4.11 66.42,4.74 65.53,4.74 63.98,6.29 63.18,6.29 R608.1 ; v2(33.25,24.45) R530.1 ; D17.N 186.41,80.54 186.41,83.7 186.92,84.21 R366.2 ; R565.1 64.11,14.04 v2(64.36,14.29)
  TOP w1.016: v5(198.86,34.36) 198.86,35.95 195.54,39.26 191.03,39.26 187.68,42.61 187.68,46.91 191.58,50.81 194.92,50.81 197.97,53.85 197.97,65.64 EC21.1
  BOTTOM w0.254: v2(26.39,46.93) 28.33,46.93 35.06,53.66 v2(35.15,53.66) ; v2(50.11,149.88) 47.92,152.08 47.92,164.22 45.38,166.76 39.94,166.76 v2(39.75,166.95)
  vias: v2(27.53,165.3) v2(28.42,165.3) v2(38.84,166.95) v5(7.66,65.03) v5(7.66,63.38) v5(8.55,64.2) v8(15.41,163.52) v8(17.37,164.09) v8(17.44,162.57) v8(19.53,163.33) v8(20.17,164.6)
+12V_4P:
  vias: v2(181.08,165.68) v2(181.14,164.41) v2(182.03,166.69) v2(183.55,166.63) v2(184.51,165.74) v2(184.57,164.34) v2(186.03,168.47) v2(187.43,164.34) v2(190.79,166.44) v2(190.79,164.34) v2(192.89,164.28) v2(194.86,166.38) v2(194.86,164.28)
+AVCC33: length 4.8
  TOP w0.203: 105.66,193.17 106.03,193.17 106.21,193.35 U4.1
  TOP w0.508: 105.66,193.17 105.07,193.17 v2(104.49,192.58) 103.42,191.51 L7.2
  BOTTOM w0.102: v3(104.49,191.71) v2(104.49,192.58)
+P1V0_PCH_VCCDSW: length 14.1
  TOP w0.203: v4(40.26,86.93) 40.25,86.92 40.25,86.45 40.02,86.22 PCH1.BA29
  TOP w0.381: C359.2 32.89,78.05 35.23,80.38 v2(35.23,80.61)
  BOTTOM w0.381: v4(40.26,86.93) 39.71,86.38 v3(39.4,86.38) 38.46,86.38 36.81,84.73 36.17,84.73 35.52,84.07 35.52,80.9 v2(35.23,80.61)
+V1P0A: length 108.4
  TOP w0.203: U31.2 48.25,27.52 48.71,27.06
  TOP w0.254: v4(51.49,90.36) 51.86,90.73 PCH1.U20 ; PCH1.AA23 v4(49.94,88.79) PCH1.Y23 ; v4(49.17,88.01) PCH1.AC26 ; PCH1.AD15 48.19,92.98 v4(48.71,93.49) ; PCH1.N17 53.81,92.36 53.31,92.86 v4(52.46,92.86) ; v4(50.72,86.46) PCH1.V28 ; PCH1.R17 52.4,91.68 v4(52.4,91.63) ; v4(51.49,88.79) PCH1.U23 ; v4(49.17,87.24) PCH1.AA28 ; v4(51.49,89.56) PCH1.U21 ; PCH1.R19 52.59,90.7 v4(52.34,90.45) ; C490.2 R503.2 51.78,29.05 v2(51.79,29.05) ; PCH1.AC23 v4(48.39,88.79) PCH1.AE23 ; PCH1.AA26 v4(49.94,88.01) PCH1.Y25 ; v4(48.39,87.24) PCH1.AC28 ; v4(48.39,88.01) PCH1.AE26 ; PCH1.AC17 v4(48.39,91.89) ; v4(50.72,87.24) PCH1.V26 ; PCH1.U25 v4(51.49,88.01) ; v6(50.72,91.89) PCH1.V17 ; v4(51.49,87.24) PCH1.U26
  TOP w0.381: PCH1.AJ20 v4(46.07,90.34) PCH1.AJ21 v4(46.07,89.56) PCH1.AJ23 v4(46.07,88.79) PCH1.AJ25
  TOP w0.508: R294.2 42.84,117.54 v2(43.41,118.12) ; R408.2 65.06,67.8 61.6,64.33 55.28,64.33 54.59,65.03 C383.2 ; R416.1 v2(43.03,67.56) ; v2(53.72,107.89) 53.9,108.07 55.4,108.07 56.93,109.61 R320.2 58.83,110.5 61.1,110.5 v2(62.69,112.08) 63.37,112.08 ; 48.71,27.06 49.66,26.1 C495.2 50.68,25.47 51.43,25.47 52.55,26.59 52.55,27.69 51.97,28.28 v2(51.97,28.31)
  BOTTOM w0.254: v2(51.79,29.05) 51.79,30.85 50.32,32.33 48.49,32.33 46.65,34.17 43.41,34.17 42.01,35.57 v2(38.46,35.57)
  BOTTOM w0.508: v2(43.03,67.56) 43.1,67.56 45.07,65.59 v2(45.44,65.59) ; v2(43.41,118.12) 43.41,117.29 46.33,114.37 47.08,114.37 53.56,107.89 v2(53.72,107.89) ; v2(62.36,114.22) 62.36,112.41 v2(62.69,112.08) ; v2(40.62,34.87) 41.63,34.87 43.09,33.41 46.65,33.41 48.34,31.72 49.58,31.72 50.19,31.11 50.19,28.72 50.6,28.31 v2(51.97,28.31)
  vias: v2(31.92,32.45) v2(32.49,33.66) v2(32.49,31.18) v2(34.27,34.04) v2(34.77,35.57) v2(35.09,31.18) v2(35.6,32.77) v2(37.57,33.53) v2(38.46,31.25) v2(39.85,32.33) v2(40.62,33.91) v2(52.68,67.25) v2(52.68,66.43) v2(53.62,75.38) v2(53.62,74.3) v2(53.62,73.35) v2(53.62,69.54) v2(53.62,68.71) v2(53.62,67.95) v2(53.62,67.19) v2(56.36,76.27) v2(56.36,75.38)
+V1P0A_VCCAMPHYPLL: length 1.6
  TOP w0.203: PCH1.B43 58.6,78.9 PCH1.C44
  BOTTOM w0.102: v3(64.03,73.93) v2(63.2,73.93)
+V1P0A_VCCAPLL: length 26.3
  TOP w0.152: v4(44.01,91.4) PCH1.AN19
  TOP w0.254: v4(44.12,97.71) 44.22,97.61 44.22,95.4 v4(44.3,95.32)
  TOP w0.508: R294.1 42.39,114.54 C291.2 C302.2 v2(42.28,109.48)
  BOTTOM w0.254: v4(44.01,91.4) v3(44.01,94.28) 44.01,95.03 v4(44.3,95.32)
  BOTTOM w0.508: v2(42.28,109.48) 43.68,108.08 43.68,98.59 44.12,98.15 v4(44.12,97.71)
+V1P0A_VCCF24_1P0: length 18
  TOP w0.152: 55,100.21 55,99.81 PCH1.K2 55.21,99.33 55.12,99.23 PCH1.K3
  TOP w0.305: 54.59,101.42 54.59,101.26 55,100.84 55,100.21
  TOP w0.508: C323.2 59.41,108.48 60.48,109.54 v1(61.01,109.54) 62.46,109.54 64.94,107.07 R327.1 ; 54.59,101.42 54.59,102.2 58.62,106.24 C325.2
+V1P0A_VCCST: length 334
  TOP w0.254: R262.1 R267.1 C238.1 ; C238.1 166.38,136.05 167.33,137.01 R259.1 ; C238.1 166.38,135.23 v2(165.84,134.69) ; R295.1 v2(45.19,116.5) ; v2(53.28,109.96) 53.57,110.25 R314.1 55.06,110.84 v2(59.41,115.19) ; C143.2 164.39,168.69 160.67,172.41 158.98,172.41 157.31,174.08 155.24,176.15 151.68,179.71 151.68,181.81 150.41,183.08 144.5,183.08 143.29,181.87 v2(140.82,181.87) ; C143.2 166.09,168.9 165.58,169.4 165.58,169.74 164.95,170.38 R164.1 R165.1 R166.1 ; C143.2 167.42,168.69 v2(168.09,168.03) 168.47,167.65 174.99,167.65 175.72,168.37 175.72,169.85 175.36,170.2 R157.2 ; R210.1 85.48,159.9 85.7,159.68 v2(85.7,159.14) ; v2(85.7,159.14) 85.7,157.42 84.37,156.09 81.06,156.09 79.86,154.88 79.86,153.87 80.26,153.46 80.26,150.2 v2(80.05,149.98) 80.05,149.51 85.92,143.64 85.92,137.68 R260.1 ; v2(85.7,159.14) 85.19,159.14 84.81,158.76 83.46,158.76 81.99,160.23 R209.1 ; v2(46.74,115.05) R300.1 46.63,114.31 44.67,112.35 R307.1 ; v2(103.54,181.87) v2(122.85,181.87)
  TOP w0.381: CPU.V4 107.36,116.66 107.92,116.66 CPU.V5 108.28,116.66 108.84,116.66 CPU.V6
  TOP w0.508: v2(101.26,116.66) 101,116.91 95.29,116.91 91.58,120.62 91.17,121.02 85.28,121.02 80.98,116.72 80.98,111.28 76.89,107.19 74.67,107.19 73.19,108.67 72.17,109.68 72.17,113.67 70.97,114.88 C295.1 ; CPU.V4 v7(106.73,116.02)
  BOTTOM w0.254: v2(59.41,115.19) 59.6,115 61.95,115 63.32,116.38 63.32,116.68 ; v2(122.85,181.87) v2(140.82,181.87) ; v2(53.28,109.96) 52.39,109.96 47.3,115.05 v2(46.74,115.05) 45.29,116.5 v2(45.19,116.5) ; v2(103.54,181.87) 103.54,180.66 90.84,167.96 90.84,164.45 85.7,159.3 v2(85.7,159.14) ; v2(165.84,134.69) 166.7,135.55 166.7,137.45 162.47,141.68 162.47,146.12 164.82,148.47 164.82,164.92 167.93,168.03 v2(168.09,168.03)
  BOTTOM w0.508: v7(106.73,116.02) 106.09,116.66 v2(101.26,116.66) ; v2(80.05,149.98) 72.61,149.98 69.1,146.47 66.7,146.47 62.46,142.23 62.46,117.54 63.32,116.68 66.27,116.68 v2(67.64,115.31)
  vias: v2(65.63,112.26)
+VBAT: length 58.7
  TOP w0.254: v2(22.2,145.13) 23.57,145.13 28.58,140.12 31.51,140.12 34.95,143.56 BAT1.P ; v2(12.68,128.47) 12.68,111.38 12.14,110.84 R318.2
  BOTTOM w0.254: v2(12.68,128.47) 12.68,137.55 13.63,138.5 14.64,138.5 15.66,139.51 17.16,139.51 17.25,139.6 19.23,139.6 20.1,140.47 21.18,140.47 22.2,141.48 v2(22.2,145.13)
+VBAT_IO: length 304.6
  TOP w0.203: 186.67,17.7 U35.66
  TOP w0.254: 186.67,17.7 187.32,17.7 C543.1 189.81,15.21 R550.2 v2(190.54,15.18) ; CLR_CMOS.2 26.14,40.52 C440.1 24.07,42.58 R463.1 23.41,44.23 22.63,44.23 21.95,44.9 21.95,51.65 17.22,56.39 15.93,56.39 14.53,55 10,55 7.16,57.83 7.16,61.98 v2(7.37,62.18)
  BOTTOM w0.254: v2(190.54,15.18) 190.03,14.67 190.03,9.45 181.21,0.64 3.09,0.64 0.64,3.09 0.64,55.45 v2(7.37,62.18)
+VCC: length 381.9
  TOP w0.254: U33.20 150.85,29.96 C466.2 ; v2(55.47,12.26) 56.24,13.02 R624.1 57.41,13.66 58.17,13.66 R587.2 58.9,11.85 C591.2
  TOP w0.508: R610.1 97.38,5.66 v2(97.77,5.28) ; R175.2 171.55,168.66 172.06,168.15 174.7,168.15 v2(175.16,168.61) ; R346.2 v2(194.92,96.08) ; v2(65.58,151.07) 66.66,149.99 74.74,149.99 76.81,147.92 76.81,142.69 74.27,140.15 74.27,139.57 71.73,137.03 R263.2 ; v2(147.93,21.85) 147.93,22.85 147.68,23.1 147.68,25.22 148.69,26.23 149.84,26.23 150.47,26.87 150.47,28.26 149.96,28.77 149.96,31.11 150.57,31.72 C466.2 ; v2(179.25,182.62) 178.28,183.59 R86.2 ; v2(32.46,160.34) 32.46,160.47 33.09,161.1 R194.1 ; v2(125.13,9.66) C579.2 R596.1 ; v2(180.85,3.02) 176.51,7.37 173.65,7.37 171.87,9.15 D26.P ; R494.1 v2(196.19,29.47) 196.95,30.23 196.95,35.7 195.75,36.9 194.94,37.71 190.43,37.71 186.16,41.98 186.16,47.54 190.95,52.33 193.65,52.33 195.3,53.98 195.3,55.89 194.92,56.27 D18.N v2(194.92,58.17) 196.19,59.44 196.19,61.54 186.14,71.58 BZ.P ; v2(150.22,191.01) 153.96,187.27 v2(154.72,187.27) 154.72,190.68 156.14,192.09 176.63,192.09 179.11,189.62 v2(179.11,188.41) ; R187.2 95.42,165.99 93.78,164.36 85.56,164.36 84.94,164.98 v2(82.91,164.98) ; v2(113.51,9.47) 113.39,9.34 R588.1 ; v2(154.72,185.3) 155.23,184.79 R85.2 ; R614.1 v2(78.49,3.88)
  TOP w1.016: Q9.S v5(129.07,184.22)
  BOTTOM w0.254: EC28.1 15.07,6.72 14.01,5.66 14.01,4.2 15.06,3.15 50.65,3.15 51.41,3.91 51.41,7.05 51.79,7.44 53.06,7.44 53.82,6.67 55.6,6.67 56.11,7.18 56.11,10.23 55.47,10.86 v2(55.47,12.26)
  BOTTOM w0.508: v2(32.46,160.34) 32.51,160.39 32.54,160.39 33.5,161.36 33.5,165.8 35.79,168.09 46.58,168.09 v5(47.03,167.65) ; v2(194.92,58.17) 194.92,64.14 190.73,68.33 190.73,91.89 v2(194.92,96.08) ; v2(154.72,185.3) v2(154.72,187.27) ; v2(150.22,191.01) 144.56,185.36 139.93,185.36 138.79,184.22 v5(129.07,184.22) ; v2(179.11,188.41) 180.19,187.33 180.19,183.56 v2(179.25,182.62) 179.25,181.96 181.86,179.34 181.86,174.28 176.19,168.61 v2(175.16,168.61) ; v2(196.19,29.47) 198.86,26.8 v2(198.86,10.74)
  vias: v2(15.28,5.47) v2(16.36,5.47) v2(17.5,5.47) v2(18.01,3.88) v2(22.64,6.8) v2(23.91,7.88) v2(23.91,5.47) v2(25.18,6.8) v2(29.19,4.07) v2(31.22,6.55) v2(32.74,6.17) v2(33,8.2) v2(33.12,3.94) v2(33.5,5.02) v2(35.28,8.2) v2(88.49,174.5) v2(88.49,173.68) v2(88.49,172.85) v2(89.38,174.5) v2(89.45,173.68) v2(89.51,172.79) v5(1.69,161.04) v5(1.69,159.52) v5(3.34,52.84) v5(3.34,51.38) v5(8.1,3.37) v5(9.94,3.37) v5(11.79,3.37) v5(46.97,155.14) v5(48.55,166.38) v5(49.51,157.04) v5(49.51,155.14) v5(54.59,5.02) v5(56.11,5.02) v5(106.66,17.34) v5(108.18,17.34) v5(109.83,17.34) v5(122.47,16.9) v5(123.8,16.9) v5(125.13,16.9)
+VCC3: length 900
  TOP w0.203: 104.69,196.22 105.01,196.22 105.24,196.46 U4.26 ; v2(110.36,195.88) 110.18,196.06 U4.14
  TOP w0.254: R544.2 v2(165.71,18.17) ; v2(21.57,64.18) 24.05,64.18 25.6,65.73 26.31,65.73 28.66,63.38 30.75,63.38 31.37,62.76 41.71,62.76 42.86,61.6 44.23,61.6 45.38,62.74 45.38,64.69 47.16,66.47 47.16,67.74 47.37,67.96 47.37,67.96 v2(47.55,68.14) 47.6,68.19 R410.2 ; R413.2 v2(51.79,68.08) ; v2(168.06,170.06) 168.38,170.38 R167.2 ; R409.2 v2(46.39,68.14) ; v2(171.36,12.13) 172.87,12.13 173.74,13 R555.2 ; v2(164.88,169.42) 163.81,170.5 R163.2 162.83,170.79 160.83,172.79 159.17,172.79 152.31,179.65 152.31,182.12 150.79,183.65 144.18,183.65 143.33,182.79 R103.1 ; R401.2 31.5,71.06 29.79,71.06 29.17,70.44 28.32,70.44 26.85,68.96 26.85,67.46 26.26,66.87 25.22,66.87 23.83,65.47 22.87,65.47 v2(22.4,65.94) v2(20.42,65.94) ; v2(28.04,79.52) 28.63,80.11 R373.2 ; CODEC.1 15.88,179.33 C105.1 ; R480.2 165.08,32.07 164.12,31.12 v2(164.12,29.66) ; R446.2 56.24,56.46 v2(55.35,55.57) ; R217.2 57.95,158.41 58.17,158.2 58.17,157.66 57.76,157.25 57.76,155.77 57.49,155.5 53.02,155.5 v2(51.66,156.85) ; PCH1.AD13 47.59,94.82 v4(47.59,95.09) ; v2(50.11,168.15) 47.98,170.29 44.95,170.29 42.51,172.73 RJ2.1 ; C163.2 R190.2 C162.2 32.72,163.39 32.13,162.81 v2(32.13,161.46) ; R400.2 21.91,71.7 19.41,71.7 18.96,72.14 18.96,73 21.22,75.25 21.79,75.25 R382.2 ; R491.2 v2(165.77,29.66) ; R414.2 52.87,70.68 v2(52.81,70.74) 52.81,71.47 R396.1
  TOP w0.305: PCIE16X.B8 13.6,156.98 11.09,156.98 7.72,153.61 R236.2
  TOP w0.381: 18.96,72.14 18.14,72.14 17.84,72.43 v2(13.5,72.43)
  TOP w0.508: Q10.G 132.31,183.33 v2(131.64,182.66) R101.1 R109.1 131.58,181.46 Q11.G 132.5,180.73 133.58,181.81 135.1,181.81 Q12.G 137.14,181.68 138.44,181.68 R103.1 ; Q6.G 141.33,200.6 140.69,199.97 135.93,199.97 v2(134.98,199.01) ; R319.1 v2(9.5,109.86) ; v2(87.92,34.55) 87.73,34.74 60.43,34.74 59.47,33.79 58.46,33.79 C445.2 ; R353.1 182.32,87.73 182.66,87.38 184,87.38 184.54,86.84 R361.1 183.49,86.43 182.98,85.92 182.98,75.95 196.95,61.98 196.95,54.55 194.09,51.69 191.21,51.69 186.79,47.27 186.79,42.25 190.67,38.37 195.17,38.37 197.59,35.96 197.59,29.66 196.32,28.39 v2(196.19,28.39) R499.1 ; v2(52.55,107.7) 52.55,107.69 52.74,107.5 52.74,106.3 52.33,105.89 C324.1 52.05,102.35 v4(51.91,102.22) ; L3.1 101.96,201.36 101.13,200.54 101.13,195.33 101.7,194.76 R27.1 ; R27.1 103.58,195.71 C28.2 103.96,196.22 104.69,196.22 ; R27.1 R35.1 101.56,193.68 101.08,193.2 101.08,191.24 101.91,190.41 L7.1 103.42,190 102.97,189.55 102.97,189.05 103.99,188.03 112.81,188.03 v2(113.77,188.98) 113.77,190.76 112.59,191.93 R41.2 113.26,193.14 113.26,193.97 R28.2 ; v2(50.88,150.26) 52.2,151.58 61.59,151.58 65.21,155.2 70.57,155.2 85.11,169.74 91.48,169.74 101.8,180.06 101.8,182.79 103.02,184.02 v2(114.66,184.02) 123.51,184.02 v2(123.75,183.77) ; R591.1 109,9.34 110.02,10.36 110.02,11.12 111.17,12.26 D25.2 111.17,13.97 110.85,14.29 ; v2(19.52,55.74) 19.52,55.67 23.12,52.07 R458.1 v2(23.12,47.25) ; v2(177.39,5.4) 179.11,3.68 179.11,3.18 ; v2(41.25,117.61) 40.62,117.61 37.64,114.64 37.64,113.75 R301.2 R302.2 R309.2 ; R257.2 10.26,137.48 v2(8.74,137.48) ; C105.1 15.42,178.78 15.42,175.82 D11.2 14.77,175.17 C132.1 14.77,171.68 R155.1 v2(18.23,171.58) 18.74,172.09 R154.2 18.96,172.12 RJ1.3 ; 179.11,3.18 178.17,2.24 129.12,2.24 TCM.9 129.13,4.39 129.13,6.93 129.32,7.12 C580.2 128.4,7.78 127.61,8.58 127.61,11.63 126.35,12.89 126.35,14.09 125.58,14.86 123,14.86 122.59,15.27 121.3,15.27 119.93,16.64 115.67,16.64 113.64,18.67 113.64,21.53 111.74,23.44 v2(111.29,23.44) 111.29,14.74 110.85,14.29 ; 179.11,3.18 180.39,1.91 189.97,1.91 190.6,2.54 190.6,6.23 189.84,6.99 R601.1 190.35,7.82 196.25,7.82 197.46,9.02 197.46,24.64 v2(196.19,25.91) R515.2 ; 110.85,14.29 106.81,14.29 R561.2 R560.2 ; v2(8.69,143.25) 9.61,143.25 R244.2 ; v2(17.37,63.7) 17.86,64.18 v2(21.57,64.18) ; v2(31.28,52.9) 43.98,52.9 45.5,51.38 51.16,51.38 52.97,53.19 R456.2 v2(53.82,53.6)
  BOTTOM w0.254: v2(28.04,79.52) 27.66,79.14 27.66,76.37 26.72,75.43 26.09,75.43 24.18,73.53 24.18,71.14 21.98,68.93 21.98,66.37 v2(22.4,65.94) ; v2(164.88,169.42) 166.09,170.63 167.49,170.63 v2(168.06,170.06) ; v2(20.42,65.94) 20.42,65.47 21.57,64.33 v2(21.57,64.18) ; v2(32.13,161.46) 31.6,160.93 31.6,160.37 32.13,159.84 32.13,156.94 30.96,155.77 EC30.1 ; v4(51.91,102.22) 48.34,98.65 48.34,95.75 47.69,95.09 v4(47.59,95.09) ; v2(46.39,68.14) v2(47.55,68.14) 48.11,67.58 50.65,67.58 51.14,68.08 v2(51.79,68.08) 52.81,69.09 v2(52.81,70.74)
  BOTTOM w0.508: v2(50.11,168.15) 50.62,167.65 50.62,157.89 v2(51.66,156.85) 51.66,151.05 v2(50.88,150.26) 50.88,149.62 50.23,148.98 49,148.98 46.49,151.48 v2(33.09,151.48) 30.96,149.36 30.96,145.61 32.61,143.96 32.61,128.09 40.68,120.02 40.68,118.18 v2(41.25,117.61) 41.57,117.61 45.5,113.67 46.58,113.67 52.55,107.69 v2(52.55,107.7) ; v2(31.28,52.9) 29.58,51.2 26.28,51.2 23.12,48.04 v2(23.12,47.25) ; v2(19.52,55.74) 20.3,56.52 20.3,57.62 21.57,58.89 v2(21.57,64.18) ; v2(110.36,195.88) 110.15,195.66 110.15,193.17 113.77,189.55 v2(113.77,188.98) 114.66,188.09 v2(114.66,184.02) ; v2(87.92,34.55) 92.94,29.53 92.94,27.25 94.53,25.66 109.89,25.66 111.29,24.26 v2(111.29,23.44) ; v2(23.22,157.04) 23.09,157.17 23.09,166.72 v2(18.23,171.58) ; v2(196.19,28.39) v2(196.19,25.91) ; v2(134.98,199.01) 134.98,190.06 132.44,187.52 126.15,187.52 123.75,185.12 v2(123.75,183.77) 127.24,183.77 128.35,182.66 v2(131.64,182.66)
  vias: v2(30.96,153.1) v2(32.36,154.37) v2(32.36,153.1) v2(33,156.53) v2(33.63,154.37) v2(33.57,153.17) v2(33.76,156.53)
+VCCGT: length 57.6
  TOP w0.254: v2(166.47,165.49) 166.79,165.17 176.25,165.17 179.05,167.96 R160.2 ; L24.2 174.82,113.8 SP13.1 ; SP11.1 174.12,123.01 L23.2
  BOTTOM w0.254: v2(166.47,165.49) 165.46,164.47 165.46,148.09 163.2,145.83 163.2,141.84 167.49,137.55 167.49,133.58 EC16.1
  vias: v2(133.33,119.07) v2(133.33,118.18) v2(133.33,117.04) v2(133.33,112.21) v2(133.33,111.32) v2(133.33,110.43) v2(133.33,109.42) v2(133.33,108.53) v2(133.33,107.13) v2(133.39,116.02) v2(133.39,115.13) v2(133.39,114.24) v2(133.39,113.23) v2(165.39,132.85) v2(165.39,125.67) v2(165.39,118.62) v2(165.39,111.45) v2(166.73,131.51) v2(166.66,126.94) v2(166.66,124.4) v2(166.73,119.83) v2(166.66,117.23) v2(166.66,112.72) v2(166.66,110.18) v2(167.93,125.67) v2(167.93,111.45) v2(168,118.56) v2(171.68,122.5) v2(171.87,112.34) v2(172,113.67) v2(172.25,123.7) v2(172.25,121.29) v2(172.57,111) v2(173.08,114.62) v2(173.39,120.53) v2(174.54,114.75) v2(174.47,111.13) v2(174.66,120.91) v4(135.41,118.74) v4(136.35,121.53) v4(136.35,120.59) v4(136.32,119.68) v4(136.32,118.76) v4(136.35,117.85) v4(136.35,116.91) v4(137.26,121.51) v4(137.31,119.68) v4(137.31,117.85) v4(137.29,115.99) v4(138.2,123.34) v4(138.18,122.42) v4(138.2,121.51) v4(138.15,120.59) v4(138.15,119.68) v4(138.18,118.79) v4(138.18,117.85) v4(138.18,116.99) v4(138.18,115.99) v4(138.18,115.16) v4(139.07,125.16) v4(139.09,123.31) v4(139.07,121.48) v4(139.09,119.68) v4(139.12,117.82) v4(139.12,115.99) v4(140.01,125.19) v4(140.03,124.25) v4(140.03,123.28) v4(140.01,122.42) v4(140.03,121.46) v4(140.01,120.59) v4(140.01,119.68) v4(140.01,118.76) v4(140.03,117.82) v4(140.01,116.99) v4(140.03,115.97) v4(140.03,115.16) v4(140.95,125.19) v4(140.92,123.34) v4(140.92,121.48) v4(140.92,119.65) v4(140.92,117.82) v4(140.92,115.99) v4(141.66,114.42) v4(141.83,123.31) v4(141.83,122.42) v4(141.81,121.51) v4(141.83,120.59) v4(141.83,119.65) v4(141.83,118.79) v4(141.83,117.8) v4(141.83,116.93) v4(141.83,115.99) v4(141.86,125.16) v4(141.86,124.25) v4(142.82,120.59) v4(142.85,125.19) v4(142.85,124.28) v4(142.88,123.36) v4(142.88,122.42) v4(142.85,121.48) v4(142.88,119.7) v4(142.88,118.79) v4(142.88,117.85) v4(142.88,116.93) v4(142.88,115.99) v5(145.71,122.24) v5(145.87,126.82) v5(146.28,117.57) v5(149.94,126.87) v5(149.89,122.29) v5(150.55,117.47) v5(154.15,126.87) v5(154.2,122.32) v5(154.34,117.61) v5(154.47,131.26) v5(157.87,131.2) v5(158.06,126.82) v5(158.06,122.24) v5(158.32,117.54) v5(161.33,131.25)
+VCCGT_PH1: length 10.6
  TOP w0.254: L23.1 179.02,123.01 178.28,123.01
  TOP w0.305: U23.7 v2(188.07,123.83)
  TOP w0.508: v2(186.67,122.81) 186.6,122.88 C260.1
  BOTTOM w0.508: v2(182.22,123.64) 183.05,122.81 v2(186.67,122.81) 187.68,123.83 v2(188.07,123.83)
  vias: v2(176.89,129.8) v2(178.22,129.8) v2(179.55,122.12) v2(179.74,127.51) v2(179.68,119.64) v2(181.33,122.43) v2(181.97,127.51) v2(182.35,119.64) v2(184.7,129.42)
+VCCGT_PH1_R: length 3.6
  TOP w0.102: C236.2 v2(178.22,136.15)
  TOP w0.508: R273.1 177.65,135.48 177.36,135.76 C236.2
  BOTTOM w0.102: v3(177.32,136.26) 177.43,136.15 v2(178.22,136.15)
+VCCGT_PH2: length 13.9
  TOP w0.254: SP14.1 179.72,113.8 L24.1
  TOP w0.305: U25.7 188.76,100.97 v2(188.95,101.16)
  TOP w0.508: C337.1 186.39,98.88 v2(186.67,99.15)
  BOTTOM w0.508: 184.66,104.72 184.66,100.48 185.98,99.15 v2(186.67,99.15) 188.67,101.16 v2(188.95,101.16)
  vias: v2(175.11,109.42) v2(177.01,109.35) v2(177.2,106.11) v2(178.92,109.35) v2(178.92,106.11) v2(179.17,112.4) v2(180.06,116.08) v2(180.95,109.42) v2(181.01,112.4) v2(181.9,115.45) v2(182.09,113.61) v2(183.49,109.42) v2(184.82,111.96) v2(184.89,115.58) v2(185.97,109.35) v2(186.03,107.19) v2(187.17,113.92)
+VCCGT_PH2_R: length 2.7
  TOP w0.102: v1(177.14,100.22) 177.41,99.95 C334.2
  TOP w0.508: R331.1 178.03,99.99 C334.2
+VCCHDA: length 25.1
  TOP w0.305: v4(39.72,93.81) PCH1.BA15
  TOP w0.381: v2(25.83,94.56) 25.83,93.24 24.21,91.61 SP18.1
  BOTTOM w0.381: v4(39.72,93.81) 39.45,94.09 35.37,94.09 29.71,99.75 27.92,99.75 25.83,97.67 v3(25.83,95.65) v2(25.83,94.56)
+VCCIO: length 69.7
  TOP w0.203: R249.2 80.91,138.75 79.41,138.75 79.03,138.37 79.03,136.76 78.45,136.17 U22.2
  TOP w0.254: 76.61,120.69 77.19,120.69 77.47,120.97 78.31,120.97 79.71,122.37 79.71,125.01 80.9,126.21 86.36,126.21 88.47,128.31 88.47,135.4 89.38,136.31 89.38,138.56 v2(90.84,140.02) ; v2(87.48,140.34) 87.48,144.6 91.95,149.07 R234.2 ; R249.2 81.89,139.29 82.3,139.7 v2(82.3,139.99)
  TOP w0.356: CPU.AK14 v4(118.07,105.05) ; CPU.AK11 v4(115.33,105.05)
  TOP w0.381: CPU.AK24 127.64,104.59 v4(127.2,105.03) 126.76,105.47 CPU.AJ23 ; CPU.M8 111.61,121.2 111.61,120.59 ; CPU.T8 111.66,118.31 ; 112.29,116.4 111.46,115.56 CPU.W8 ; CPU.U8 111.66,117.39 ; 111.02,119.96 CPU.P8
  BOTTOM w0.254: v2(90.84,140.02) 90.53,140.34 v2(87.48,140.34) 87.48,140.33 87.17,140.02 82.33,140.02 v2(82.3,139.99)
  BOTTOM w0.508: 118.07,106.04 v4(118.07,105.05)
  vias: v2(75.69,112.46) v2(76.45,112.45) v2(77.41,112.45) v2(113.2,110.24) v2(113.51,111.83) v2(113.51,111.07) v2(113.96,110.24) v3(77.8,110.41)
+VCCK_V12: length 15.2
  TOP w0.203: 104.87,196.86 U4.25 ; U4.4 107.41,192.59
  TOP w0.508: v2(106.46,191.46) 106.6,191.32 107.12,191.32 C49.2 107.16,191.75 107.41,191.99 107.41,192.59 ; 104.87,196.86 103.64,196.86 C16.2 103.16,197.33 C11.2 103.8,198.25 v2(104.43,197.62)
  BOTTOM w0.508: v2(106.46,191.46) 105.87,192.05 v3(105.87,193.11) 105.87,196.18 v2(104.43,197.62)
+VCCPFUSE_3P3: length 0.8
  BOTTOM w0.089: v3(36.83,100.83) v2(36.83,100.02)
+VCCPGPPA: length 22.8
  TOP w0.254: v4(40.32,85.59) 39.95,85.22 PCH1.BA31
  TOP w0.508: R417.2 34.96,67.63 v2(34.65,67.32)
  BOTTOM w0.508: v2(34.65,67.32) 35.81,68.48 v3(35.81,76.17) 36.4,76.75 36.4,80.33 37.21,81.15 37.53,81.15 38.1,81.72 38.1,83.53 40.16,85.59 v4(40.32,85.59)
+VCCPGPPD: length 1
  BOTTOM w0.102: v2(38.08,73.4) 37.92,73.55 v3(37.92,74.29)
+VCCPLL_OC_R: length 4.1
  TOP w0.356: CPU.AJ9 111.76,107.28 113.86,109.38 R321.1
+VCCPRIM_1P0: length 22.5
  TOP w0.152: v4(45.07,90.4) 45.07,89.94 PCH1.AL22
  TOP w0.381: v2(42.72,70.78) 43.03,70.48 R416.2
  BOTTOM w0.305: v4(45.07,90.4) 44.36,89.68 44.36,82.94 44.73,82.57 44.73,80.51 43.79,79.57 43.79,78.63 43.26,78.1 43.26,76.7 v3(42.72,76.17) v2(42.72,70.78)
+VDD1.0: length 13
  TOP w0.203: 58.09,167.12 58.2,167.01 U19.8 ; U19.3 60.2,167.9 C148.1 ; U19.22 60.2,161.36 59.72,160.88 ; 62.73,164.6 62.51,164.82 U19.30
  TOP w0.508: 62.73,164.6 C165.1 v2(63.38,165.36) ; v2(57,167.25) C146.1 C147.1 58.08,167.14 58.09,167.12 ; C148.1 60.84,167.99 v2(61.16,168.32) ; 59.72,160.88 59.03,160.19 C185.1 59.13,159.71 v2(59.72,159.71)
  vias: v2(64.55,160.41) v2(65.13,160.91) v3(63.25,163.57)
+VDD33: length 55.6
  TOP w0.203: 56.47,164.82 U19.11 ; U19.32 61.81,165.62 62.51,166.31
  TOP w0.508: C96.2 v2(67.39,179.9) 67.6,179.69 67.6,177.09 66.96,176.44 R131.2 R130.2 63.25,175.58 54.59,175.58 53.95,174.95 Q15.D ; C94.2 v2(72.01,179.86) ; v2(54.39,168.03) C155.2 54.39,166.03 C159.2 ; U11.5 v2(69.84,180.24) ; C159.2 53.79,164.72 R193.2 ; C159.2 55.6,164.82 56.47,164.82 ; 62.51,166.31 62.51,166.77 63.01,167.26 C152.2 63.38,167.61 v2(63.86,168.09) ; USB2_LAN.14 78.86,184.97 79.79,184.03 C97.1 80.43,180.89 80.43,179.83 D8.N 79.08,178.47 R121.2 v2(78.72,177.62) ; U12.5 v2(74.11,180.05)
  BOTTOM w0.508: v2(67.39,179.9) 67.73,180.24 v2(69.84,180.24) 70.22,179.86 v2(72.01,179.86) 72.2,180.05 v2(74.11,180.05) 76.28,180.05 v2(78.72,177.62)
  vias: v2(54.43,171.14) v2(54.43,170.38) v2(61.57,158.76) v2(62.31,158.74)
+VDD_DAC_33: length 12.1
  TOP w0.102: L3.2 v2(104.42,201.36)
  TOP w0.203: 108.46,199.99 108.46,198.41 107.81,197.76 107.81,197.72 107.81,197.72 U4.20
  TOP w0.508: L3.2 C5.2 106.91,202.44 108.46,200.89 108.46,199.99
  BOTTOM w0.102: v3(104.42,202.2) v2(104.42,201.36)
+VIN_CPU: length 71.9
  TOP w0.254: R162.2 172.7,170.28 v2(172.7,168.98)
  TOP w0.762: v8(79.86,156.34) 77.19,153.68 77.19,149.46 83.88,142.77 83.88,136.44 ; C120.2 101.1,175.49 92.14,166.53 v8(89.29,166.53)
  BOTTOM w0.254: v2(172.19,160.53) 172.7,161.04 v2(172.7,168.98)
  BOTTOM w0.762: v8(89.29,166.53) 89.29,164.47 85.62,160.8 83.49,160.8 79.86,157.17 v8(79.86,156.34)
  vias: v2(110.21,174.31) v2(110.34,171.46) v2(111.67,177.42) v2(111.86,168.41) v2(111.93,167.46) v2(111.93,166.57) v2(115.55,174.19) v2(118.85,177.55) v2(118.85,171.33) v2(121.83,171.58) v2(121.83,170.63) v2(124.44,171.58) v2(125.64,171.58) v2(127.42,171.58) v2(128.5,174.44) v2(128.56,171.58) v2(128.56,170.5) v2(130.02,175.84) v2(130.02,172.92) v2(131.48,174.44) v2(141.2,172.6) v2(141.2,171.65) v2(145.01,173.42) v2(145.01,172.28) v2(145.01,171.27) v2(147.74,171.39) v2(147.8,169.8) v2(147.8,168.34) v2(147.8,166.82) v2(177.08,161.61) v2(177.78,158.88) v2(178.22,162.31) v2(179.11,159.01) v2(179.81,159.77) v2(181.78,159.77) v2(183.43,159.77) v2(184.95,159.84) v2(186.16,158.18) v2(190.22,155.26) v2(190.28,149.23) v2(191.24,110.43) v2(191.49,149.23) v2(191.68,156.72) v2(191.75,117.48) v2(191.75,114.62) v2(191.81,153.8) v2(191.94,132.09) v2(192.7,142.56) v2(192.82,149.23) v2(192.76,147.52) v2(192.76,146.37) v2(192.76,145.17) v2(192.76,130.37) v2(192.76,129.1) v2(192.76,127.96) v2(192.76,125.42) v2(193.14,155.26) v2(193.14,132.09) v2(193.21,116.08) v2(193.4,110.37) v2(193.9,127.96) v2(193.9,125.35) v2(194.09,149.23) v2(194.09,142.56) v2(195.3,110.37)
