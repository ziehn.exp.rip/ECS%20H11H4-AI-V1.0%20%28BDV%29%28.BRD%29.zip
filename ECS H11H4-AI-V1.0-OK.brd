# Allegro board ECS H11H4-AI-V1.0-OK.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PEG_TX_P9: length 99.8
  TOP w0.089: 99.82,125.67 99.84,125.67 99.85,125.68 101.73,125.68 102.91,124.5 103.77,124.5 104.13,124.14 105.64,124.14 105.74,124.03 105.74,123.9 105.64,123.79 CPU.K2
  TOP w0.102: v7(93.43,128.06) 93.76,127.73 93.76,127.32 95.42,125.67 99.82,125.67 ; C282.1 22.76,117.27 22.76,117.59 23.03,117.86 24.39,117.86 29.47,122.94 29.47,125.63 32.91,129.08 35.99,129.08 37.69,130.78 38.78,130.78 42.16,134.16 61.53,134.16 62.73,132.96 63.86,132.96 64.63,132.19 65.25,132.19 65.91,131.53 66.79,131.53 66.98,131.72 66.98,131.87 v7(66.65,132.2)
  BOTTOM w0.102: v7(93.43,128.06) 93.76,128.39 93.76,128.59 93.08,129.28 73.23,129.28 71.88,130.63 67.64,130.63 66.98,131.29 66.98,131.87 v7(66.65,132.2)
PEG_TX_P10: length 100.5
  TOP w0.089: 99.82,124.99 99.84,124.99 99.85,124.99 101.68,124.99 103.59,123.08 104.01,123.08 104.19,123.26 104.66,123.26 104.79,123.13 104.79,122.99 104.68,122.88 CPU.L1
  TOP w0.102: v2(65.15,130.03) 65.48,129.7 65.48,129.55 65.35,129.42 64.3,129.42 61.09,132.63 42.58,132.63 39.35,129.41 38.26,129.41 36.56,127.7 33.48,127.7 30.89,125.11 30.89,122.3 25.6,117.02 25.6,116.05 23.16,113.61 22.84,113.61 22.58,113.35 22.58,113.11 C304.1 ; 99.82,124.99 92.29,124.99 90.7,126.57 90.7,126.99 v7(90.4,127.3)
  BOTTOM w0.102: v7(90.4,127.3) 90.7,127.6 90.7,127.78 90.58,127.91 72.64,127.91 71.39,129.15 68.11,129.15 67.88,128.92 65.98,128.92 65.48,129.42 65.48,129.7 v2(65.15,130.03)
PEG_TX_P11: length 119
  TOP w0.089: v7(100.13,124.28) 100.33,124.28 100.5,124.11 100.5,123.31 101.21,122.6 103.79,122.6 104.06,122.32 105.59,122.32 105.7,122.2 105.7,122.04 105.62,121.96 CPU.M2
  TOP w0.102: C330.1 11.22,102.46 11.22,102.62 11.58,102.98 13.29,102.98 13.64,102.63 14.91,102.63 15.54,103.27 16.87,103.27 17.64,104.03 17.64,104.73 18.19,105.28 19.39,105.28 20.4,106.29 21.32,106.29 21.87,106.84 21.87,108.17 24.9,111.19 24.9,113.08 27.25,115.44 27.25,116.32 32.46,121.53 32.46,124.45 34.14,126.13 37.21,126.13 38.91,127.83 40.02,127.83 43.24,131.06 60.32,131.06 63.55,127.83 66.24,127.83 66.75,128.34 67.35,128.34 67.56,128.13 67.56,127.93 67.36,127.73 v7(67.18,127.73)
  BOTTOM w0.102: v7(100.13,124.28) 100.31,124.28 100.53,124.5 100.53,124.72 99.51,125.75 72.76,125.75 71.7,126.82 67.87,126.82 67.59,127.09 67.59,127.55 67.42,127.73 v7(67.18,127.73)
PEG_TX_P12: length 120.5
  TOP w0.089: CPU.N1 104.69,121.05 104.79,121.15 104.79,121.28 104.63,121.43 104.24,121.43 103.91,121.1 102.85,121.1 102.53,121.42 102.53,121.87 102.41,121.99 v7(102.22,121.99)
  TOP w0.102: C339.1 11.22,98.33 11.22,98.62 11.61,99.01 13.19,99.01 13.58,98.62 14.71,98.62 15.37,99.28 16.83,99.28 17.93,100.38 17.93,100.86 18.36,101.29 19.39,101.29 20.38,102.28 21.34,102.28 21.85,102.79 21.85,104.37 23.24,105.76 23.24,107.6 26.27,110.62 26.27,112.47 28.63,114.83 28.63,115.69 33.93,121 33.93,123.99 34.71,124.76 37.78,124.76 39.48,126.46 40.59,126.46 43.81,129.69 59.64,129.69 63.78,125.55 65.94,125.55 66.56,126.17 69.5,126.17 69.85,125.82 69.85,125.47 69.69,125.31 v2(69.43,125.31)
  BOTTOM w0.102: v7(102.22,121.99) 102.4,121.99 102.53,122.12 102.53,122.42 102.1,122.85 98.65,122.85 97.12,124.38 70.18,124.38 69.85,124.71 69.85,125.19 69.73,125.31 v2(69.43,125.31)
PEG_TX_P13: length 121.5
  TOP w0.089: v7(99.23,120.87) 99.47,120.87 99.62,120.72 99.62,120.36 99.96,120.02 102.65,120.02 103.15,120.52 105.54,120.52 105.69,120.36 105.69,120.19 105.64,120.13 CPU.P2
  TOP w0.102: C344.1 11.22,94.14 11.22,94.37 11.49,94.63 14.91,94.63 15.54,95.27 16.85,95.27 17.96,96.38 17.96,96.94 18.3,97.27 19.34,97.27 20.35,98.29 21.27,98.29 21.85,98.88 21.85,100.31 23.23,101.68 23.23,103.8 24.61,105.19 24.61,107.03 27.64,110.05 27.64,111.86 30,114.22 30,115.03 40.05,125.09 41.16,125.09 44.38,128.31 59.03,128.31 63.19,124.15 64.87,124.15 65.08,123.94 65.08,123.7 64.91,123.54 v7(64.67,123.54)
  BOTTOM w0.102: v7(64.67,123.54) 64.92,123.54 65,123.46 65,123.01 65.32,122.69 66.04,122.69 66.8,123.45 68.05,123.45 68.49,123.01 96.49,123.01 98.04,121.46 99.38,121.46 99.59,121.24 99.59,121.02 99.44,120.87 v7(99.23,120.87)
PEG_TX_P14: length 122.2
  TOP w0.089: 97.38,120.66 97.41,120.66 97.41,120.66 97.79,120.66 98.87,119.58 104.7,119.58 105.05,119.22 CPU.R2
  TOP w0.102: C347.1 11.25,90.17 11.25,90.37 11.5,90.62 14.87,90.62 15.53,91.28 16.88,91.28 17.51,91.91 17.51,92.88 17.94,93.31 19.39,93.31 20.38,94.3 21.29,94.3 21.87,94.88 21.87,95.94 23.23,97.3 23.23,99.67 24.62,101.06 24.62,103.25 25.98,104.61 25.98,106.46 29.01,109.49 29.01,111.25 31.5,113.73 31.5,114.57 40.64,123.72 41.73,123.72 44.95,126.94 58.38,126.94 64.27,121.05 65.31,121.05 65.63,121.37 65.63,121.58 v2(65.91,121.86) ; 97.38,120.66 95.47,120.66 v7(95.23,120.91)
  BOTTOM w0.102: v2(65.91,121.86) 65.66,121.6 65.66,121.25 65.91,121 67.95,121 68.69,120.26 84.05,120.26 84.94,121.15 92.03,121.15 92.58,120.6 94.92,120.6 v7(95.23,120.91)
PEG_TX_P15: length 127.7
  TOP w0.089: CPU.T2 105.64,118.31 105.72,118.38 105.72,118.57 105.59,118.69 97.41,118.69 97.41,118.69 97.38,118.69
  TOP w0.102: v7(96.12,119.53) 96.26,119.53 96.43,119.36 96.43,118.98 96.72,118.69 97.38,118.69 ; v2(64.96,119.02) 65.26,119.02 65.38,119.14 65.38,119.45 65.15,119.67 63.69,119.67 57.79,125.57 45.52,125.57 42.29,122.34 41.23,122.34 32.87,113.99 32.87,113.1 30.38,110.61 30.38,108.92 27.36,105.89 27.36,104.03 25.99,102.66 25.99,100.41 24.6,99.02 24.6,96.66 23.24,95.31 23.24,93.82 21.87,92.45 21.87,91.07 21.12,90.32 20.43,90.32 19.39,89.27 18.27,89.27 17.91,88.91 17.91,88.28 16.9,87.27 15.54,87.27 14.88,86.61 13.54,86.61 13.04,87.11 11.49,87.11 11.21,86.84 11.21,86.65 C351.1
  BOTTOM w0.102: v2(64.96,119.02) 65.26,119.02 65.38,119.14 65.38,119.94 65.76,120.31 67.65,120.31 68.5,119.46 84.23,119.46 85.23,120.47 91.64,120.47 93.34,118.76 96.16,118.76 96.43,119.03 96.43,119.4 96.29,119.53 v7(96.12,119.53)
PERSTB: length 7.1
  TOP w0.102: U19.19 59,161.44 57.82,160.27 57.77,160.27 57.31,159.8 C184.1 56.44,159.37 56.44,158.57 56.41,158.54 56.41,158.53 56.13,158.26 v1(56.13,157.93) 55.35,157.14 R223.1
PEX16_100M_N: length 81.2
  TOP w0.102: v2(30.1,143.43) 30.43,143.76 30.43,143.93 30.28,144.09 28.61,144.09 24.04,148.66 22.78,148.66 20.9,150.54 19.95,150.54 19.66,150.25 19.66,149.83 19.93,149.56 PCIE16X.A14 ; v4(51.14,95.76) 51.07,95.83 PCH1.W10
  BOTTOM w0.102: v2(30.1,143.43) 30.43,143.1 30.43,125.44 40.82,115.05 42.5,115.05 46.37,111.18 47.77,111.18 50.57,108.38 50.57,107.3 51.76,106.11 54.18,106.11 55.65,104.64 55.65,98.2 53.6,96.14 53.02,96.14 52.4,95.52 51.38,95.52 v4(51.14,95.76)
PEX16_100M_P: length 81.2
  TOP w0.102: v4(51.14,95.09) 51.11,95.07 PCH1.W11 ; v2(30.96,143.43) 30.63,143.76 30.63,144.02 30.36,144.29 28.7,144.29 24.13,148.86 22.87,148.86 20.99,150.74 19.86,150.74 19.68,150.56 PCIE16X.A13
  BOTTOM w0.102: v4(51.14,95.09) 51.37,95.32 52.49,95.32 53.11,95.94 53.68,95.94 55.86,98.11 55.86,104.73 54.26,106.32 51.84,106.32 50.78,107.38 50.78,108.46 47.85,111.38 46.46,111.38 42.58,115.26 40.9,115.26 30.63,125.53 30.63,143.1 v2(30.96,143.43)
PEX16_RST: length 4.9
  TOP w0.102: R241.1 v1(6.58,151.05) 7.33,151.8 R236.1 R237.1 D14.3
PEX16_RST_L: length 13.8
  TOP w0.102: PCIE16X.A11 17.97,155.27 15.57,155.27 14.49,156.34 11.15,156.34 9.5,154.69 9.5,153.68 9.88,153.29 C206.1 R237.2
PLTRST_R_N: length 15.8
  TOP w0.089: PCH1.BB27 39.19,87.39 39.09,87.29 38.24,87.29 38.21,87.32 36.98,87.32 36.22,86.56 36.22,85.4 35.28,84.46 35.28,81.86 34.54,81.12 34.54,80.56 32.69,78.71 32.02,78.71
  TOP w0.102: R376.1 30.3,78.02 30.99,78.71 32.02,78.71
PM_DOWN: length 67.6
  TOP w0.089: 47.51,105.69 47.51,105.07 46.12,103.68 PCH1.AH2
  TOP w0.102: 47.51,105.69 47.51,106.23 49.81,108.53 52.87,108.53 54.39,110.05 55.23,110.05 60.24,115.06 v2(60.24,116.83) ; R238.1 v2(72.87,151.52)
  BOTTOM w0.102: v2(60.24,116.83) 60.24,117.07 v3(60.76,117.59) 61.01,117.85 61.01,142.45 66.13,147.57 68.55,147.57 72.49,151.52 v2(72.87,151.52)
PM_SYNC: length 19.5
  TOP w0.089: PCH1.AJ4 45.79,98.81 45.79,99.22 45.7,99.3 45.7,104.31 46.75,105.36 46.75,105.69
  TOP w0.102: 46.75,105.69 46.75,106.48 49.56,109.29 50.78,109.29 51.88,110.39 51.88,112.08 52.59,112.79 v1(53.14,112.79) 53.57,113.23 R299.1
PME_L: length 28.3
  TOP w0.089: PCH1.BD17 38.33,92.06 38.32,92.07 37.18,92.07 36.23,91.13 36.23,88.52 34.28,86.57 34.28,85.07 34.06,84.86 34.06,82.31 33.33,81.58 33.33,81.07 32.33,80.08 32.02,80.08
  TOP w0.102: 32.02,80.08 29.36,80.08 28.09,78.81 v1(27.76,78.81) 27.58,78.63 27.58,71.87 27.12,71.41 R398.1
POL1: length 3.4
  TOP w0.102: U4.10 110.36,194.46 v1(110.57,194.25) 111.25,194.25 111.48,194.02 112.13,194.02 R36.1
POL2: length 2.9
  TOP w0.102: U4.9 109.87,194.06 110.16,193.77 110.16,193.46 110.62,193.01 111.11,193.01 R41.1
POP: length 116.6
  TOP w0.254: R4.1 16.52,205.08 16.89,204.71 16.89,202.85 16.49,202.44 v3(16.49,201.75) 16.49,201.33 R13.1 R14.1 ; R4.1 17.15,206 18.26,206 18.61,205.65 R5.1 R6.1 20.45,206.06 22.07,206.06 22.42,205.71 R7.1 R8.1 23.88,205.9 24.23,206.25 26.49,206.25 26.93,205.81 R9.1 R10.1 28.3,205.59 v2(28.3,206.25) ; R4.1 15.88,206 15.06,206 R3.1 13.66,206.13 12.14,206.13 R2.1 R1.1 10.23,205.84 9.94,206.13 8.42,206.13 7.73,205.44 7.73,202.96 6.07,201.3 4.36,201.3 1.69,198.63 1.69,178 3.94,175.74 R142.2 ; Q13.C 35.85,176.85 v2(36.23,177.23)
  BOTTOM w0.254: v2(28.3,206.25) 29.55,205 29.55,201.81 25.45,197.71 25.45,197.14 26.04,196.55 27.6,196.55 33.27,190.89 37.25,190.89 39.39,188.74 39.39,186.7 35.6,182.9 35.6,177.87 v2(36.23,177.23)
POP_R: length 3.3
  TOP w0.102: R142.1 v2(9.12,174.79)
  TOP w0.254: R142.1 10.01,174.14 10.14,174.01 Q19.B
  BOTTOM w0.102: v3(9.37,175.66) 9.37,175.04 v2(9.12,174.79)
PROC_SEL_L: length 1.8
  TOP w0.102: CPU.AB36 v7(139.1,112.36)
  BOTTOM w0.089: STP5.1 139.13,112.39 v7(139.1,112.36)
PROCHOT_L: length 25.3
  TOP w0.102: CPU.C39 144.64,132.53 144.64,133.64 147.27,136.26 159.54,136.26 v2(160.72,137.44) 160.95,137.67 R258.2
  BOTTOM w0.102: v2(160.72,137.44) 160.71,137.46 v3(159.82,137.46)
PROCPWRGD: length 16.7
  TOP w0.089: 44.9,105.69 44.9,105.08 44.62,104.8 44.62,99.31 44.33,99.02 PCH1.AM3
  TOP w0.102: R297.1 48.93,112.93 v3(48.72,112.72) 48.72,110.82 44.9,107 44.9,105.69
QN9TS_BLEED: length 3.3
  TOP w0.102: QN3.1 144.34,23.25 v1(144.55,23.46)
  TOP w0.254: R520.2 143.96,24.36 143.47,23.87 QN3.1
QN9TS_BLEED_D: length 2.9
  TOP w0.102: R522.2 v1(139.87,22.87)
  TOP w0.254: QN3.3 R522.2
REGOUT_1:
  vias: v1(62.43,161.79)
RLAN_PWR_EN: length 203.5
  TOP w0.089: 32.02,86.83 33.95,88.76 33.95,92.9 35.46,94.41 37.57,94.41 37.64,94.33 PCH1.BD13
  TOP w0.102: v2(9.59,71.56) 10.74,72.71 11.47,72.71 12.55,73.79 18.82,73.79 20.98,75.95 20.98,76.62 22.04,77.68 22.69,77.68 R375.1 23.12,78.33 23.58,78.8 23.61,78.8 27.28,82.47 27.28,85.41 28.17,86.3 31.49,86.3 32.02,86.83 ; D12.S v2(43.47,175.16)
  BOTTOM w0.102: v2(43.47,175.16) 41.05,172.74 24.85,172.74 24.17,173.42 24.17,174.3 23.78,174.69 22.01,176.46 22.01,178.19 20.04,180.16 14.39,180.16 13.82,179.58 13.82,177.3 15.41,175.71 15.41,174.19 16.46,173.13 16.46,168.36 14.53,166.43 13.06,166.43 10.54,163.91 10.54,162.34 2.31,154.11 2.31,79.96 3.84,78.43 5.94,76.33 5.94,74.81 5.14,74.01 4.08,74.01 3.73,73.66 3.73,72.9 4.48,72.15 v3(7.57,72.15) 8.46,72.15 9.06,71.56 v2(9.59,71.56)
RLAN_PWR_EN_R: length 9.1
  TOP w0.254: U15.3 44.96,170.89 43.71,172.13 43.71,172.48 v1(43.28,172.92) 43.03,172.92 42.33,173.61 42.33,176.28 D12.D 42.46,177.39 R126.1
RSMRST_L: length 343
  TOP w0.089: v4(39.82,95.75) 39.86,95.71 PCH1.BA11
  TOP w0.102: v2(22.99,86.84) 23.22,86.61 C354.1 23.67,85.05 23.67,82.6 R368.1 22.69,81.62 22.07,81.62 17.33,76.88 14.45,76.88 13.28,75.71 11.86,75.71 9.5,73.35 v2(9.5,72.52) ; U35.82 186.4,24.1 186.86,23.64 186.86,22.48 188.25,21.09 C528.1 189.4,20.54 190.98,20.54 R537.1 192.48,21.06 192.82,20.71 Q55.C 192.82,18.93 v2(192.63,18.74)
  BOTTOM w0.089: 31.26,100.43 36.09,95.6 39.66,95.6 v4(39.82,95.75)
  BOTTOM w0.102: v2(192.63,18.74) 192.63,18.61 190.35,16.33 v3(188.89,16.33) 185.95,13.39 185.95,9.82 177.71,1.57 65.27,1.57 63.91,2.94 62.05,2.94 60.68,1.57 4.06,1.57 1.83,3.8 1.83,54.46 10.01,62.64 10.01,65.99 9.32,66.68 9.32,69 10.25,69.93 10.25,70.71 10.59,71.06 10.59,71.81 10.13,72.27 9.88,72.52 v2(9.5,72.52) ; 31.26,100.43 30.28,101.42 26.98,101.42 22.99,97.42 v2(22.99,86.84)
RSMRST_L1_1: length 5.4
  TOP w0.102: R564.2 194.29,16.71 v2(193.94,17.05) 193.65,17.34 Q61.B
  BOTTOM w0.102: v2(193.94,17.05) v3(193.04,17.05)
RSMRST_L1_2: length 8.4
  TOP w0.102: R572.2 194.93,12.28 194.93,13.51 C565.1 195.36,14.55 195.11,14.8 Q61.C v2(195.11,17.8) Q55.B
  BOTTOM w0.102: v3(195.11,18.7) v2(195.11,17.8)
RSMRST_L1_3: length 5.4
  TOP w0.102: R562.2 191.17,13.94 R563.1 C564.1 R564.1 v2(194.29,12.16)
  BOTTOM w0.102: v3(194.29,13.07) v2(194.29,12.16)
RSTIN_L: length 5.4
  TOP w0.102: R480.1 167.89,31.77 v1(168.5,31.77) 169.25,32.52 171.04,32.52 171.59,31.97 U35.128
RTCRST_L: length 76.6
  TOP w0.089: 32.02,96.46 C340.1 32.87,96.46 33.95,95.39 38.51,95.39 38.64,95.51 PCH1.BC10
  TOP w0.102: 32.02,96.46 31.98,96.46 v2(31.47,95.95) ; v2(16.17,55.63) 16.33,55.8 17.2,55.8 21.52,51.48 21.52,44.56 22.52,43.57 R463.2
  BOTTOM w0.102: v2(31.47,95.95) 32.41,95.01 32.41,92.63 v3(32.97,92.07) 33.38,91.66 33.38,89.99 30.66,87.27 25.83,87.27 23.77,85.21 23.77,81.63 20.84,78.69 20.84,76.98 20.09,76.24 20.09,73.17 20.6,72.66 20.6,70.35 18.9,68.64 18.9,65.09 20.02,63.98 20.02,62.68 16.79,59.46 16.79,56.25 v2(16.17,55.63)
RTCX1_IN: length 13
  TOP w0.089: PCH1.BC9 39,96.09 38.74,95.83 38.16,95.83 38.1,95.77 36.66,95.77 36.35,96.08 35.98,96.08 32.74,99.32 32.74,99.61 R344.1 32.14,100.21 32.02,100.21
  TOP w0.102: 32.02,100.21 C333.1 30.68,100.65 29.38,100.65 28.93,100.21 R343.1
RTCX1_IN_S: length 2.2
  TOP w0.102: R343.2 28.17,99.19 27.41,98.43 27.41,97.73
RTCX2_OUT: length 10.9
  TOP w0.089: PCH1.BD10 38.24,95.61 38.21,95.58 36.58,95.58 36.39,95.76 35.76,95.76 32.36,99.16 R344.2 32.02,99.16
  TOP w0.102: 32.02,99.16 31.15,99.16 C335.1 30.68,98.68 30.2,98.68 29.95,98.43 Y2.2
SATA3_RX_N0: length 96.5
  TOP w0.089: PCH1.G35 56.94,82.67 v4(57.07,82.54)
  TOP w0.102: C473.2 73.11,30.97 72.83,30.97 v7(72.57,30.72)
  BOTTOM w0.089: v4(57.07,82.54) 57.25,82.73 57.25,83.24 57.96,83.95 59.05,83.95 59.88,83.12 60.4,83.12 60.41,83.13 60.43,83.13
  BOTTOM w0.102: 60.43,83.13 65.19,83.13 69.52,78.8 69.52,71.19 58.65,60.32 56.22,60.32 49.78,53.88 49.78,36.91 53.98,32.71 73.03,32.71 73.58,32.16 73.58,31.42 73.14,30.97 72.83,30.97 v7(72.57,30.72)
SATA3_RX_N1: length 97.3
  TOP w0.089: PCH1.D39 57.96,81.43 57.73,81.43 57.59,81.28 v4(57.59,81.09)
  TOP w0.102: C478.2 70.21,29.18 70.99,29.18 71.16,29.35 v7(71.16,29.51)
  BOTTOM w0.089: 60.43,80.98 60.41,80.98 60.4,80.97 59.27,80.97 58.72,80.42 57.43,80.42 57.11,80.74 57.11,81.23 57.23,81.34 57.34,81.34 v4(57.59,81.09)
  BOTTOM w0.102: v7(71.16,29.51) 71.16,29.32 70.94,29.1 69.75,29.1 67.78,31.07 53.59,31.07 47.43,37.23 46.6,37.23 44.37,39.46 44.37,50.43 55.84,61.9 58.15,61.9 64.75,68.49 64.75,70.8 68.06,74.11 68.06,78.19 65.27,80.98 60.43,80.98
SATA3_RX_P0: length 96.5
  TOP w0.089: v4(57.73,82.59) 57.73,83.08 PCH1.E35
  TOP w0.102: v2(72.57,31.67) 72.57,31.31 72.71,31.18 73.37,31.18 73.48,31.28 C469.2
  BOTTOM w0.089: v4(57.73,82.59) 57.59,82.59 57.44,82.75 57.44,83.16 58.04,83.76 58.97,83.76 59.8,82.93 60.4,82.93 60.41,82.92 60.43,82.92
  BOTTOM w0.102: 60.43,82.92 65.11,82.92 69.32,78.71 69.32,71.28 58.56,60.52 56.14,60.52 49.58,53.96 49.58,36.82 53.9,32.5 72.95,32.5 73.38,32.07 73.38,31.51 73.05,31.18 72.68,31.18 72.57,31.29 v2(72.57,31.67)
SATA3_RX_P1: length 97.3
  TOP w0.089: PCH1.E37 57.49,81.75 v4(57.37,81.75)
  TOP w0.102: C483.2 70.25,28.97 70.83,28.97 v2(71.16,28.64)
  BOTTOM w0.089: 60.43,80.78 60.41,80.78 60.4,80.78 59.35,80.78 58.8,80.23 57.35,80.23 56.92,80.66 56.92,81.31 v4(57.37,81.75)
  BOTTOM w0.102: 60.43,80.78 65.19,80.78 67.86,78.11 67.86,74.2 64.54,70.88 64.54,68.57 58.07,62.1 55.76,62.1 44.17,50.51 44.17,39.38 46.52,37.03 47.35,37.03 53.51,30.87 67.7,30.87 69.66,28.9 70.91,28.9 v2(71.16,28.64)
SATA3_TX_N0: length 98.8
  TOP w0.102: v7(61.05,84.4) 61.32,84.13 61.32,83.76 60.56,83 59.09,83 58.93,82.84 PCH1.C36 ; C479.2 73.04,29.09 72.65,29.09 72.45,29.3 v2(72.45,29.43)
  BOTTOM w0.102: v7(61.05,84.4) 61.3,84.14 61.3,83.9 61.57,83.64 65.41,83.64 70.21,78.84 70.21,71.19 58.77,59.76 56.39,59.76 50.28,53.65 50.28,37.14 54.22,33.2 73.36,33.2 74.21,32.36 74.21,29.91 73.39,29.09 72.65,29.09 72.45,29.3 v2(72.45,29.43)
SATA3_TX_N1: length 90.4
  TOP w0.089: v7(61.32,82.24) 61.54,82.24 61.65,82.14 61.65,81.89 61.4,81.64 60.07,81.64 59.97,81.75 59.22,81.75 59.18,81.78 PCH1.B38
  TOP w0.102: C472.2 70.23,31.11 71.07,31.11 71.17,31.01 v2(71.17,30.78)
  BOTTOM w0.102: v7(61.32,82.24) 61.52,82.24 61.67,82.09 61.67,81.78 61.98,81.48 65.57,81.48 68.56,78.49 68.56,73.91 65.24,70.6 65.24,68.23 58.31,61.3 55.94,61.3 48.88,54.24 48.88,36.51 53.77,31.62 68.12,31.62 68.62,31.11 71.06,31.11 71.17,31.01 v2(71.17,30.78)
SATA3_TX_P0: length 98.7
  TOP w0.102: v4(61.76,84.4) 61.52,84.16 61.52,83.68 60.64,82.8 59.27,82.8 PCH1.B36 ; v7(72.45,28.56) 72.78,28.89 73.04,28.89 C484.2
  BOTTOM w0.102: v4(61.76,84.4) 61.51,84.14 61.51,83.99 61.65,83.84 65.49,83.84 70.41,78.92 70.41,71.11 58.86,59.56 56.48,59.56 50.48,53.56 50.48,37.22 54.3,33.41 73.44,33.41 74.41,32.44 74.41,29.83 73.47,28.89 72.78,28.89 v7(72.45,28.56)
SATA3_TX_P1: length 90.3
  TOP w0.089: PCH1.C38 58.67,81.76 58.88,81.56 59.89,81.56 59.99,81.45 61.48,81.45 61.84,81.81 61.84,82 v4(62.08,82.24)
  TOP w0.102: C468.2 70.23,31.32 70.84,31.32 v7(71.17,31.65)
  BOTTOM w0.102: v7(71.17,31.65) 70.84,31.32 68.7,31.32 68.2,31.82 53.86,31.82 49.09,36.59 49.09,54.16 56.02,61.09 58.4,61.09 65.44,68.14 65.44,70.51 68.76,73.83 68.76,78.58 65.65,81.68 62.06,81.68 61.87,81.87 61.87,82.03 v4(62.08,82.24)
SATA3R_N0: length 13.7
  TOP w0.102: C473.1 74.43,30.71 74.88,31.16 75.78,31.16 76.05,31.44 82.43,31.44 85.12,28.75 85.12,28.29 84.53,27.71 SATA1.5
SATA3R_N1: length 10.1
  TOP w0.102: C478.1 68.41,29.16 67.94,29.16 66.64,30.46 63.07,30.46 61.6,28.99 61.6,28.51 SATA2.5
SATA3R_P0: length 13.7
  TOP w0.102: C469.1 74.76,31.36 75.69,31.36 75.97,31.64 82.51,31.64 85.32,28.83 85.32,28.37 SATA1.6
SATA3R_P1: length 10.1
  TOP w0.102: SATA2.6 62.14,27.77 61.8,28.11 61.8,28.91 63.16,30.26 66.56,30.26 67.86,28.96 68.54,28.96 68.84,28.66 C483.1
SATA3T_N0: length 10.7
  TOP w0.102: SATA1.3 81.43,28.45 81.43,28.91 79.4,30.94 76.28,30.94 75.21,29.87 75.21,29.43 74.94,29.15 74.55,29.15 74.43,29.27 C479.1
SATA3T_N1: length 13.7
  TOP w0.102: SATA2.3 58.28,27.77 58,28.05 58,28.91 59.35,30.26 61.89,30.26 62.74,31.11 68.55,31.11 68.84,30.82 C472.1
SATA3T_P0: length 10.7
  TOP w0.102: C484.1 74.43,28.73 74.65,28.95 75.02,28.95 75.41,29.34 75.41,29.79 76.37,30.74 79.32,30.74 81.23,28.83 81.23,27.98 80.95,27.71 SATA1.2
SATA3T_P1: length 13.7
  TOP w0.102: C468.1 68.4,31.32 62.66,31.32 61.8,30.46 59.26,30.46 57.8,29 57.8,28.52 SATA2.2
SATALED_L: length 176.5
  TOP w0.089: 48.11,72.99 48.11,71.52 ; PCH1.AD44 48.16,78.77 48.16,78.06 48.16,78.06 48.16,76.47 48.11,76.42 47.55,75.86 47.55,74.27
  TOP w0.102: 48.11,72.99 48.11,73.71 47.55,74.27 ; 48.11,71.52 48.11,70.33 R410.1 48.06,69.37 48.06,67.71 47.7,67.35 47.7,63.67 46.38,62.35 v2(46.03,62.35) ; Q66.E 104.18,12.2 104.69,12.71 R560.1 104.25,13.42 104.25,17.98 v2(103.67,18.56)
  BOTTOM w0.102: v2(103.67,18.56) 99.47,18.56 v3(98.83,19.2) 98.46,19.56 94.32,19.56 89.68,24.2 55.05,24.2 53.52,22.68 40.95,22.68 40.62,23.01 35.28,23.01 33.72,21.44 30.72,21.44 28.17,18.89 20.4,18.89 18.01,21.28 18.01,33.03 21.82,36.84 21.82,39.78 22.49,40.46 22.49,44.86 21.76,45.6 21.76,48.01 25.98,52.24 29.12,52.24 33.21,56.33 37.49,56.33 42.7,61.54 45.21,61.54 v2(46.03,62.35)
SATALED_L_B: length 2.4
  TOP w0.102: v1(105.58,12.99) R561.1 106.46,12.32 106.21,12.07 Q66.B
SDI: length 3.8
  TOP w0.102: R137.2 20.23,177.46 20.27,177.5 20.27,178.34 v3(19.98,178.63) 19.98,178.89 19.46,179.41 CODEC.8
SENSE-A: length 5.6
  TOP w0.254: R116.1 R115.1 R114.1 25.28,180.38 23.82,181.84 CODEC.13
SENSE-B: length 7.1
  TOP w0.254: R38.2 R39.2 13.25,191.27 v3(14.14,190.38) 14.52,190 16.74,190 16.96,189.78 CODEC.34
SERIRQ: length 297.2
  TOP w0.089: PCH1.BA17 39.87,92.13 v4(40.27,92.81)
  TOP w0.102: U35.36 172.84,16.66 172.97,16.79 172.97,17.88 172.76,18.1 172.76,18.47 173.41,19.12 175.55,19.12 v2(176,19.56) ; v2(133.9,10.9) 133.9,7.45 135.5,5.85 TCM.16 ; R400.1 22.66,70.99 v2(21.44,70.99)
  BOTTOM w0.102: v4(40.27,92.81) 40.13,92.95 38.6,92.95 38.1,92.45 36.68,92.45 30.91,86.68 26.09,86.68 24.36,84.96 24.36,81.07 22.94,79.65 22.94,76.95 20.78,74.8 20.78,73.5 21.44,72.84 v2(21.44,70.99) 21.44,69.87 20.94,69.37 20.94,68.38 19.94,67.38 19.94,65.53 21.06,64.41 21.06,61.51 19.36,59.81 19.36,58.93 18.9,58.48 18.9,57.04 19.21,56.74 19.21,56.34 18.64,55.77 18.64,55.25 15.22,51.83 15.22,45.43 14.03,44.24 14.03,36.56 12.19,34.72 12.19,19.16 12.95,18.4 12.95,17.83 12.95,13.38 15.05,11.28 30.11,11.28 34.88,16.05 41.49,16.05 42.8,17.37 56.14,17.37 58.01,15.5 64.46,15.5 65.38,14.58 65.38,13.66 65.93,13.11 66.22,13.11 67.83,11.5 68.94,11.5 70.68,9.76 82.01,9.76 82.69,9.08 95.84,9.08 98.53,11.77 116.27,11.77 117.32,10.71 119.37,10.71 119.62,10.97 133.83,10.97 v2(133.9,10.9) 134.32,11.32 137.22,11.32 138.2,10.34 139.59,10.34 140.53,11.28 142.05,11.28 143.15,10.18 144.09,10.18 145.63,8.64 149.58,8.64 150.39,9.45 167.13,9.45 168.1,8.48 172.41,8.48 176.06,12.13 176.06,14.48 175.72,14.83 175.72,19.28 v2(176,19.56)
SIO_24M: length 252.9
  TOP w0.102: U35.44 176.04,14.11 C560.1 175.58,14.07 v2(175.3,13.79) ; v4(30.14,82.17) 30.39,82.43 R371.2
  BOTTOM w0.102: v4(30.14,82.17) 28.87,80.9 28.87,79.08 28.23,78.44 28.23,76 27.1,74.87 26.34,74.87 24.79,73.32 24.79,70.27 26.75,68.32 26.75,67.15 25.22,65.63 25.22,60.32 21.84,56.94 21.84,55.07 17.18,50.41 17.18,38.34 13.75,34.91 13.75,28.67 13.16,28.07 13.16,19.56 14.24,18.48 14.24,13.48 15.47,12.25 29.65,12.25 34.42,17.02 41.09,17.02 42.4,18.33 56.54,18.33 58.26,16.62 65.11,16.62 66.57,15.16 85.9,15.16 86.84,14.22 90.6,14.22 92.09,12.73 117.41,12.73 118.69,11.45 133.4,11.45 133.76,11.8 137.42,11.8 138.4,10.83 139.39,10.83 140.33,11.77 143.55,11.77 v3(145.72,9.59) 146.19,9.12 148.39,9.12 149.2,9.94 167.33,9.94 167.81,9.45 168.21,9.45 170.88,9.45 175.21,13.79 v2(175.3,13.79)
SIO_CLKIN: length 251.1
  TOP w0.102: v2(172.79,14.07) C559.1 172.04,14.09 U35.34 ; R372.2 30.34,81.36 v4(30.14,81.16)
  BOTTOM w0.102: v4(30.14,81.16) 29.82,80.84 29.82,79.27 29.08,78.53 29.08,76.14 27.31,74.36 26.52,74.36 25.3,73.14 25.3,70.5 27.31,68.5 27.31,67.03 25.71,65.43 25.71,60.12 22.33,56.74 22.33,54.87 17.67,50.21 17.67,38.14 14.25,34.73 14.25,24.58 13.77,24.1 13.77,22.04 14.25,21.56 14.25,19.25 14.72,18.78 14.72,13.77 15.76,12.73 29.45,12.73 34.22,17.5 40.8,17.5 42.11,18.81 55.04,18.81 56.74,20.52 63.03,20.52 67.91,15.64 86.35,15.64 87.29,14.7 90.88,14.7 92.37,13.21 94.42,13.21 94.94,13.73 117.09,13.73 117.93,12.89 118.89,11.93 133.2,11.93 133.56,12.29 137.62,12.29 138.6,11.31 139.19,11.31 140.13,12.25 146.92,12.25 148.75,10.42 167.53,10.42 168.01,9.94 169.61,9.94 v3(169.98,10.31) 171.05,10.31 173.5,12.75 173.5,13.42 172.85,14.07 v2(172.79,14.07)
SIO_GND: length 33.9
  TOP w0.203: U35.83 186.39,24.5 187.62,23.28 187.62,22.74
  TOP w0.508: R484.2 v2(190.67,30.55) C474.2 ; C504.2 C505.1 R523.1 194.48,23.12 L31.2 193.65,22.29 v2(191.43,22.29) 190.9,21.77 188.59,21.77 187.62,22.74 ; C497.1 v2(190.67,25.85) ; R508.2 v2(190.67,27.31) C489.2 ; C481.2 v2(190.67,29.47) R493.2 ; C485.2 v2(190.67,28.39) R498.2 ; C470.2 v2(190.67,31.63) ; C461.2 v2(190.67,32.71)
  BOTTOM w0.508: v2(190.67,32.71) v2(190.67,31.63) v2(190.67,30.55) v2(190.67,29.47) v2(190.67,28.39) v2(190.67,27.31) v2(190.67,25.85) 191.43,25.09 v3(191.43,24.39) v2(191.43,22.29)
SIO_GP16: length 257.5
  TOP w0.089: R387.1 41.82,71.52
  TOP w0.102: v2(176.44,22.17) 175.87,22.74 174.67,22.74 173.78,23.63 172.5,24.9 172.5,29.91 172.04,30.38 U35.127 172.04,32.03 170.92,33.15 R474.1 ; v2(41.89,70.78) 41.82,70.85 41.82,71.52
  BOTTOM w0.102: v2(41.89,70.78) 42.44,70.22 42.44,67.3 40.03,64.89 40.03,59.91 37.2,57.08 32.99,57.08 28.84,52.93 25.46,52.93 20.92,48.38 20.92,36.98 17.27,33.33 17.27,20.87 19.94,18.2 28.63,18.2 31.02,20.6 34.15,20.6 35.87,22.32 40.26,22.32 40.64,21.94 53.76,21.94 55.33,23.51 89.4,23.51 95.53,17.38 104.74,17.38 105.89,18.53 110.97,18.53 112.19,17.32 120.09,17.32 120.85,18.08 133.6,18.08 135.75,20.22 142.06,20.22 143.21,21.38 144.98,21.38 150.65,15.72 165.73,15.72 170.3,20.29 172.14,20.29 v3(172.7,19.73) 173.19,19.23 174.21,19.23 174.47,19.5 174.47,19.96 176.44,21.93 v2(176.44,22.17)
SIO_LED0: length 85
  TOP w0.102: U35.11 169.34,25.7 168.25,26.79 168.25,27.18 167.87,27.56 164.95,27.56 v2(164.76,27.76) ; v2(100.58,20.54) 101.28,19.84 101.28,14.79 R557.2 R556.2
  BOTTOM w0.102: v2(100.58,20.54) 101.04,20.08 101.91,20.08 102.41,20.58 111.51,20.58 113.63,18.46 119.62,18.46 120.38,19.22 128.17,19.22 129.57,20.62 134.07,20.62 136.45,22.99 142.85,22.99 145.2,25.34 v3(155.02,25.34) 155.55,25.34 158.27,28.06 164.45,28.06 v2(164.76,27.76)
SIO_LED0_R: length 2.4
  TOP w0.102: v1(99.54,12.99) R556.1 98.65,12.39 98.97,12.07 Q64.B
SIO_LED1: length 82.4
  TOP w0.102: v2(168.76,27.37) 168.76,26.8 169.06,26.5 U35.9 ; R559.1 R558.2 v2(101.51,20.57)
  BOTTOM w0.102: v2(101.51,20.57) 101.82,20.87 111.54,20.87 113.73,18.69 119.52,18.69 120.29,19.45 128.08,19.45 129.48,20.85 133.98,20.85 136.35,23.22 142.76,23.22 145.56,26.03 v3(152.83,26.03) 155.91,26.03 158.17,28.29 164.92,28.29 165.84,27.37 v2(168.76,27.37)
SIO_LED1_R: length 2.3
  TOP w0.102: v1(103.48,13.02) 103.45,12.99 R559.2 Q65.B
SIO_PECI: length 407.9
  TOP w0.102: R578.2 181.08,10.61 v2(180.19,9.72) ; R231.2 73.89,155.83 70.58,152.53 65.03,152.53 62.18,149.68 54.33,149.68 52.03,147.38 34.32,147.38 32.77,145.83 28.76,145.83 24.76,149.83 24.1,149.83 23.57,150.36 22.63,150.36 v2(22.43,150.56)
  BOTTOM w0.102: v2(22.43,150.56) 22.43,149.94 21.08,148.59 20.1,148.59 19.03,147.52 15.79,147.52 14.71,146.44 12.87,146.44 8.61,142.18 8.61,140.68 9.4,139.9 9.4,136.85 8.71,136.16 8.71,131.59 8.1,130.98 8.1,118.05 8.61,117.54 8.61,113.67 8.1,113.16 8.1,102.49 7.62,102.01 7.62,95.98 6.9,95.26 6.9,86.49 7.69,85.7 7.69,81.09 9.17,79.62 10.29,79.62 11.16,78.75 11.48,78.43 11.7,78.21 11.7,77.14 13.82,75.02 13.82,74.31 13.03,73.52 13.03,72.9 12.84,72.71 12.84,72.16 13.59,71.41 13.59,70.18 12.83,69.41 12.83,68.49 12.04,67.71 12.04,63 6.07,57.03 6.07,51.25 2.92,48.1 2.92,10.71 5.9,7.73 5.91,7.73 9.02,4.61 9.36,4.28 13.18,4.28 14.08,3.38 14.79,2.67 60.21,2.67 61.62,4.08 64.41,4.08 65.83,2.67 96.01,2.67 97.92,4.58 99.15,4.58 100.11,5.55 100.11,6.42 100.58,6.89 118.33,6.89 120.61,4.6 175.07,4.6 v3(179.15,8.68) v2(180.19,9.72)
SIO_PECI_R: length 5.5
  TOP w0.102: R578.1 181.08,12.46 v1(181.15,12.54) 181.15,13.17 C561.1 179.78,14.55 179.24,14.55 178.84,14.94 U35.51
SIO_PWRON_L: length 329.1
  TOP w0.089: PCH1.AT13 41.87,94.7 v4(41.87,94.71)
  TOP w0.102: v2(182.41,19.63) 183.14,18.9 U35.69 188.69,18.9 R542.1
  BOTTOM w0.089: 31.26,99.79 35.88,95.16 40.07,95.16 40.21,95.3 41.28,95.3 v4(41.87,94.71)
  BOTTOM w0.102: 31.26,99.79 30.14,100.91 27.12,100.91 24.19,97.98 24.19,87.15 22,84.96 22,81.35 17.86,77.21 17.86,61.77 15.02,58.93 15.02,53.98 11.2,50.16 11.2,45.97 12.43,44.73 12.43,37.25 9.06,33.87 9.06,32.41 7.91,31.27 5.97,31.27 5.08,30.38 5.08,11.61 6.8,9.89 9.54,9.89 10.39,10.74 11.6,10.74 13.16,9.17 17.34,9.17 18.52,7.99 20.37,7.99 20.56,7.99 22.48,9.91 26.44,9.91 27.18,9.18 27.41,8.95 29.83,8.95 30.8,9.91 31.06,10.18 31.06,10.18 35.54,14.66 42.05,14.66 43.39,15.99 55.45,15.99 57.79,13.66 59.28,13.66 60.05,12.9 60.05,11.4 60.85,10.59 65.27,10.59 66.08,9.78 66.88,9.78 68.96,7.7 96.64,7.7 98.34,9.4 109.58,9.4 110.12,9.95 115.44,9.95 116.42,8.97 119.01,8.97 119.49,8.49 130.39,8.49 131.08,9.19 134.84,9.19 135.6,9.95 136.58,9.95 137.97,8.57 142.06,8.57 144.3,6.33 145.72,6.33 146.56,7.17 175.91,7.17 178.32,9.58 178.32,12.76 v3(178.03,13.05) 178.03,14.92 177.23,15.72 177.23,18.11 178.24,19.12 181.9,19.12 v2(182.41,19.63)
SIO_VCC3: length 9.6
  TOP w0.203: 188,26.61 187.49,27.12 187.04,27.12 186.82,26.9 U35.89
  TOP w0.508: 188,26.61 v1(193.42,26.61) 193.97,26.61 194.38,26.21 R515.1
SIO_VCC3_1: length 3.5
  TOP w0.508: R601.2 v1(189.84,10.05) 189.84,10.86 189.27,11.44 Q63.D
SIO_VCORE: length 4.8
  TOP w0.305: U35.33 171.59,15.24 170.98,14.63 C558.1
  TOP w0.508: C551.1 169.3,14.42 v1(169.65,14.07) C558.1
SIO_VREF: length 6.8
  TOP w0.203: C497.2 188.06,25.85 187.3,26.61 v1(187.25,26.61) 187,26.61 186.89,26.5 U35.88
  TOP w0.254: C497.2 188.95,25.22 191.01,25.22 R516.1
SLP_AMT_L: length 35.1
  TOP w0.089: PCH1.BC15 38.68,93.24 38.54,93.09 36.36,93.09 34.96,91.7 34.96,88.65 33.33,87.01 33.33,85.93 32.02,84.63
  TOP w0.102: v2(24.07,67.71) 24.07,68.36 24.27,68.56 24.27,69.97 24.76,70.46 24.76,77.15 25.15,77.54 25.15,79.01 28.05,81.91 28.05,81.92 28.19,82.07 28.19,82.69 28.76,83.25 29.5,83.25 29.59,83.34 30.73,83.34 32.02,84.63
  BOTTOM w0.102: v2(24.07,67.71) 24.21,67.57 STP30.1
SLP_LAN_L: length 6.7
  TOP w0.089: PCH1.AV15 41.39,93.43 v4(41.68,93.74)
  BOTTOM w0.089: STP11.1 36.54,93.14 39.96,93.14 40.05,93.23 41.17,93.23 v4(41.68,93.74)
SLP_S0_L: length 6.7
  TOP w0.089: v4(35.46,85.54) 35.46,86.35 36.81,87.7 38.22,87.7 38.25,87.73 38.57,87.73 38.79,87.51 PCH1.BC26
  BOTTOM w0.089: v4(35.46,85.54) 34.47,84.55 STP17.1
SLP_S3_L: length 598.9
  TOP w0.089: PCH1.AW15 v4(41.01,93.68)
  TOP w0.102: v2(13.12,74.54) 13.37,74.8 18.77,74.8 20.31,76.33 20.31,77.2 v2(21.45,78.34) ; v2(19.79,9.02) 20.12,9.35 20.12,9.9 20.61,10.4 U37.1 ; v2(189.21,87.7) 187.81,87.7 187.3,88.21 D16.1 ; v2(12.32,46.27) 13.03,45.56 U27.5 ; U14.1 91.22,180.28 91.54,180.6 91.54,183.39 91.16,183.77 90.46,183.77 89.07,182.38 89.07,179.89 87.4,178.22 87.4,171.94 87.07,171.61 84.43,171.61 69.88,157.07 64.52,157.07 60.93,153.47 51.05,153.47 47.47,149.89 30.09,149.89 26.09,153.89 v2(23.91,153.89) ; R464.1 22.9,41.15 21.17,42.89 21.17,51.33 17.66,54.84 17.31,55.19 v2(16.87,55.19) ; v2(179.74,20.33) 180.57,19.5 181.59,19.5 182.58,18.5 U35.68 ; v2(7.95,117.24) 8.97,117.24 9.97,118.24 R293.1
  BOTTOM w0.089: v4(41.01,93.68) 40.8,93.47 40.02,93.47 39.88,93.34 35.96,93.34 35.89,93.26
  BOTTOM w0.102: v2(189.21,87.7) 189.21,65.79 v3(191.05,63.95) 191.66,63.34 191.66,53.07 186.5,47.91 186.5,41.38 187,40.88 187,38.37 181.2,32.58 181.2,21.28 180.25,20.33 v2(179.74,20.33) 177.97,20.33 176.17,18.53 176.17,15.19 176.57,14.8 176.57,11.63 172.95,8.01 167.93,8.01 166.94,9 150.83,9 149.99,8.16 146.56,8.16 145.42,7.02 144.66,7.02 142.41,9.26 140.34,9.26 140.11,9.49 138.08,9.49 136.93,10.64 135.32,10.64 134.59,9.91 129.45,9.91 128.72,9.17 119.78,9.17 119.29,9.66 116.75,9.66 115.77,10.64 107.42,10.64 106.67,9.89 98.18,9.89 96.45,8.16 69.25,8.16 67.34,10.08 67.34,10.55 66.76,11.12 61.09,11.12 60.55,11.65 60.55,13.28 59.67,14.17 58.04,14.17 55.75,16.45 43.18,16.45 41.84,15.11 35.35,15.11 30.61,10.37 21.13,10.37 v2(19.79,9.02) 19.27,8.51 18.65,8.51 17.53,9.63 13.35,9.63 9.69,13.29 9.69,33.86 12.89,37.06 12.89,45.14 12.32,45.71 v2(12.32,46.27) 12.32,46.96 12.47,47.11 12.47,50.67 16.87,55.06 v2(16.87,55.19) 17.15,55.47 17.15,59.31 20.37,62.53 20.37,64.12 19.25,65.24 19.25,68.5 20.96,70.2 20.96,72.87 20.45,73.37 20.45,76.09 21.45,77.09 v2(21.45,78.34) 21.45,78.67 24.13,81.35 24.13,85.06 25.98,86.91 30.81,86.91 33.76,89.86 33.76,91.13 35.89,93.26 ; v2(13.12,74.54) 13.12,75.09 11.29,76.92 11.29,78.04 10.12,79.21 9,79.21 7.25,80.96 7.25,85.53 6.49,86.29 6.49,95.52 7.21,96.25 7.21,102.22 7.7,102.7 7.7,116.99 v2(7.95,117.24) 7.7,117.49 7.7,131.18 8.18,131.67 8.18,143.66 13.11,148.59 14.58,148.59 15.51,149.52 19.28,149.52 20.28,150.52 20.95,150.52 23.91,153.49 v2(23.91,153.89)
SLP_S3_L_R: length 5.1
  TOP w0.102: Q45.S 26.01,34.54 23.22,37.33 Q44.D
SLP_S4_L: length 493.9
  TOP w0.089: PCH1.BD15 38.24,93.34 38.19,93.29 36.17,93.29 34.71,91.83 34.71,88.68 33.11,87.08 33.11,86.1 32.02,85.01
  TOP w0.102: v2(176.06,23.63) 178.28,23.63 179.55,22.36 181.22,22.36 182.85,20.73 184.46,20.73 184.63,20.9 U35.74 ; v2(91.57,23.41) 91.57,24.16 93.64,26.23 107.29,26.23 107.99,26.93 R501.1 ; R549.2 v2(100.31,19.25) ; R315.2 57.62,111.31 55.4,109.09 v2(54.61,109.09) ; v2(22.34,62.71) 22.34,62.36 24.26,60.44 28.12,60.44 28.48,60.09 30.25,60.09 31.37,61.21 33.76,61.21 35.94,59.02 v2(35.94,55.7) ; v2(19.84,153.43) 21.29,153.43 22.68,152.04 25.68,152.04 29.88,147.83 v2(31.84,147.83) ; v2(147.23,22.48) 146.89,22.83 146.89,25.63 147.23,25.98 Q51.G ; v2(12.42,70.3) 12.42,69.79 15.09,67.13 20.4,67.13 v2(20.63,67.35) 20.93,67.05 23.27,67.05 23.58,67.37 23.58,68.2 24.04,68.66 24.04,70.07 24.53,70.55 24.53,77.25 24.92,77.64 24.92,79.11 27.97,82.16 27.97,82.79 28.66,83.48 29.4,83.48 29.49,83.57 30.58,83.57 32.02,85.01
  BOTTOM w0.102: v2(12.42,70.3) 12.83,70.7 12.83,71.28 12.21,71.9 12.21,72.97 12.4,73.16 12.4,75.17 10.83,76.73 10.83,77.85 9.93,78.75 8.81,78.75 6.77,80.8 6.77,85.35 6.03,86.09 6.03,95.78 6.73,96.47 6.73,102.65 7.09,103 7.09,105.8 7.09,131.08 6.71,131.46 6.71,136.59 7.72,137.61 7.72,145.8 12.44,150.52 14.98,150.52 15.73,151.27 16.47,151.27 16.72,151.02 17.78,151.02 19.84,153.08 v2(19.84,153.43) ; v2(31.84,147.83) 31.84,147.15 33.33,145.66 33.33,129.72 48.93,114.12 50.45,114.12 54.61,109.95 v2(54.61,109.09) ; v2(20.63,67.35) 20.94,67.04 20.94,65.61 22.34,64.21 v2(22.34,62.71) ; v2(176.06,23.63) 175.22,23.63 v3(174.68,23.08) 172.9,21.31 169.99,21.31 167.35,18.67 165.27,18.67 163.67,17.07 150.66,17.07 147.42,20.31 147.42,22.29 v2(147.23,22.48) 146.14,22.48 145.72,22.07 136.28,22.07 133.64,19.42 131.05,19.42 130.69,19.78 129.38,19.78 128.36,18.76 120.57,18.76 119.81,18 112.66,18 111.42,19.25 v2(100.31,19.25) 99.76,19.79 94.69,19.79 93.57,20.91 93.57,22.24 92.41,23.41 v2(91.57,23.41) 91.19,23.41 90.17,24.43 54.95,24.43 53.45,22.93 41.05,22.93 40.74,23.23 35.03,23.23 33.53,21.73 30.56,21.73 27.94,19.12 20.49,19.12 18.24,21.37 18.24,32.88 22.1,36.75 22.1,39.58 22.72,40.2 22.72,45 22,45.73 22,47.87 26.14,52.01 29.26,52.01 32.94,55.7 v2(35.94,55.7)
SLP_S4_L_R: length 4.4
  TOP w0.102: v1(100.13,14.93) 100.31,15.11 R549.1 99.64,15.85 98.97,16.52 Q59.G
SLP_S4_L_R_D: length 11.6
  TOP w0.102: Q59.D 97.38,16.07 96.94,15.63 R553.2 96.38,13.99 96.38,12.69 96.94,12.13 Q64.E 96.94,11.12 97.45,10.61 v2(99.29,10.61) 99.99,10.61 100.56,11.18 Q65.E
  BOTTOM w0.102: v2(99.29,10.61) 99.39,10.71 v3(100.18,10.71)
SLP_S4_L_REV: length 7.2
  TOP w0.102: R521.1 R520.1 144.76,26.29 144.95,26.49 Q51.D v2(143.74,27.69) 143.36,27.31 Q50.G
  BOTTOM w0.102: v2(143.74,27.69) 143.74,27.86 v3(144.32,28.44)
SLP_VCCST_S4: length 8.2
  TOP w0.102: U24.5 64.01,113.72 63.25,112.95 v2(63.25,112.79) 63.04,112.59 61.95,112.59 61.74,112.38 C303.1 R315.1 ; v2(63.25,114.22) 63.54,114.52 U24.3
  BOTTOM w0.102: v2(63.25,112.79) 63.83,113.38 v3(63.83,113.48) 63.83,113.63 v2(63.25,114.22)
SLPSUS_L: length 279.3
  TOP w0.089: PCH1.BB13 39.15,94.21 39.06,94.11 38.21,94.11 38.18,94.14 37.53,94.14 37.45,94.22 35.54,94.22 34.14,92.82 34.14,88.66 32.72,87.24 32.72,86.51 32.02,85.81
  TOP w0.102: v2(168.82,28.77) 168.95,28.9 U35.3 ; 32.02,85.81 30.24,84.03 29.3,84.03 29.22,83.94 28.47,83.94 27.51,82.97 27.51,82.37 24.46,79.32 24.46,77.84 24.07,77.46 24.07,70.81 23.58,70.32 23.58,68.85 22.8,68.06 21.85,68.06 21.35,68.56 20.7,69.21 16.42,69.21 v2(15.47,68.26) ; v2(26.26,48.77) 25.76,48.77 24.31,50.22 24.31,52.45 20.14,56.62 20.14,57.31 19.69,57.77 17.09,57.77 16.52,57.19 15.76,57.19 15,56.43 13.89,56.43 13.49,56.84 11.3,56.84 10.34,55.87 9.55,55.87 8.17,57.26 8.17,58.01 8.61,58.46 R443.2 R434.1 9.12,60.3 11.56,60.3 v2(12.61,59.25)
  BOTTOM w0.102: v2(168.82,28.77) 168.82,28.7 168.01,27.89 166.71,27.89 165.96,28.64 158.19,28.64 156.24,26.69 v3(150.39,26.69) 145.78,26.69 142.66,23.56 136.36,23.56 133.87,21.07 129.38,21.07 127.98,19.68 120.19,19.68 119.43,18.92 113.82,18.92 111.4,21.34 95.99,21.34 91.73,25.6 54.61,25.6 52.93,23.92 41.55,23.92 41.17,24.3 34.11,24.3 33.45,24.96 31.66,24.96 26.89,20.19 20.94,20.19 19.3,21.82 19.3,32.42 23.09,36.2 23.09,38.94 23.79,39.64 23.79,45.03 25.85,47.08 25.85,48.35 v2(26.26,48.77) ; v2(12.61,59.25) 12.61,59.38 15.24,62.01 15.24,68.03 v2(15.47,68.26)
SLS3_BF: length 24.7
  TOP w0.102: R277.1 4.55,129.01 v1(4.55,127.88) 4.55,126.59 R279.1 4.67,125.45 4.67,122.91 R282.1 4.67,121.89 4.67,119.29 R287.1 4.65,118.25 4.65,117.16 5.18,116.63 7.8,116.63 8.2,116.22 8.2,112.22 R304.1 R305.1 9.28,112.88 Q30.D
SLS3_BF_R1: length 2.4
  TOP w0.102: 6.52,119.45 5.47,119.45 R287.2 v1(5.18,120.67)
SLS3_BF_R2: length 2.4
  TOP w0.102: Q27.B 5.47,123.07 R282.2 v1(5.18,124.3)
SLS3_BF_R3: length 3.6
  TOP w0.102: R304.2 7.28,112.24 Q29.B
SLS3_BF_R4: length 9.2
  TOP w0.102: v1(4.67,131.49) 4.67,131.1 R277.2 5.47,130.31 Q25.B 7.15,130.31 7.6,129.86 7.6,127.2 7.09,126.69 Q26.B 5.89,126.69 5.67,126.91 R279.2
SLS3_BF_R5: length 4.5
  TOP w0.102: R293.2 C275.2 11.18,116.76 10.96,116.53 Q30.G 10.96,115.14 v2(10.69,114.88)
  BOTTOM w0.102: v3(10.62,113.99) 10.62,114.8 v2(10.69,114.88)
SLS3_BF_R6: length 3
  TOP w0.102: R303.1 5.21,112.95 v2(5.31,113.05) 5.8,113.54 Q29.C
  BOTTOM w0.102: v2(5.31,113.05) 5.41,112.95 v3(5.41,112.13)
SMB_STBY_MAIN_G: length 13.5
  TOP w0.102: Q43.G 49.95,55.19 50.36,55.19 R451.2 52.05,57.66 Q38.G 52.96,60.36 52.96,62.86 v1(52.63,63.19) 52.31,63.51 Q35.D
SMB_STBY_MAIN_G_G: length 8.8
  TOP w0.102: Q37.D 50.24,60.37 50.24,62.96 v2(49.71,63.49) 49.19,64.01 Q35.G 49.19,65.16 50.08,66.05 R424.2
  BOTTOM w0.102: v2(49.71,63.49) 49.35,63.14 v3(48.92,63.14)
SMBALERT_L: length 15.4
  TOP w0.089: v4(39.49,80.47) PCH1.BB41
  TOP w0.102: R427.1 39.56,67.22 38.92,67.86 v2(38.84,67.86)
  BOTTOM w0.102: v2(38.84,67.86) 38.84,68.98 v3(37.74,70.07) 37.74,70.88 37.75,70.89 37.75,72 38.56,72.81 38.56,79.54 v4(39.49,80.47)
SMBCLK_MAIN: length 313.9
  TOP w0.102: R447.1 R446.1 56.01,58.55 Q38.S 53.19,57.85 53.7,57.35 v2(55.35,57.35) ; v2(69.86,84.41) 69.86,93.77 74.08,97.99 74.08,106.84 70.78,110.14 64.45,110.14 v2(64.11,109.8) ; R35.2 103.61,193.68 v2(104.43,194.51) 104.79,194.86 U4.30 ; v2(112.88,20.71) 112.88,18.48 115.29,16.07 119.88,16.07 126.21,9.74 R597.1
  BOTTOM w0.102: v2(104.43,194.51) 104.43,194.32 102.08,191.97 102.08,188.46 102.73,187.81 102.73,180.78 91.22,169.27 86.34,169.27 78.6,161.54 74.92,161.54 70.65,157.27 67.08,157.27 50.75,140.94 50.75,121.74 62.1,110.39 63.52,110.39 v2(64.11,109.8) ; v2(112.88,20.71) 112.37,20.71 111.48,21.6 96.11,21.6 91.16,26.55 91.16,28.72 87.35,32.53 81.23,32.53 v3(80.7,33.06) 79.58,34.18 57.09,34.18 56.49,34.79 54.1,34.79 53.37,35.52 53.37,36.77 52.96,37.18 51.5,38.65 51.46,38.69 51.46,53.85 54.95,57.35 v2(55.35,57.35) 56.93,58.93 58.96,58.93 70.9,70.88 70.9,80.16 69.38,81.68 69.38,83.93 v2(69.86,84.41)
SMBCLK_STBY: length 403.1
  TOP w0.102: Q38.D 51.4,60.84 50.33,59.77 50.33,58.49 48.55,56.71 48.55,55.76 47.75,54.96 45.36,54.96 44.55,54.15 36.25,54.15 35.37,55.02 v2(35.37,57.6) 35.37,59.21 33.6,60.98 31.5,60.98 30.38,59.86 28.38,59.86 28.04,60.2 24.07,60.2 21.9,62.38 15.65,62.38 10.69,67.33 10.69,68.46 v2(10.41,68.74) ; R579.2 182.16,10.48 180.52,8.84 174.29,8.84 172.89,10.24 172.23,10.91 170.19,10.91 168.85,12.25 167.52,12.25 166.83,12.94 166.83,15.08 v2(166.35,15.56) ; R393.1 40.84,71.49 v2(40.84,70.74) 40.84,70.12 R405.1
  BOTTOM w0.102: v2(10.41,68.74) 10.6,68.74 11.71,69.85 11.71,70.64 11.51,70.84 11.51,72.23 8.24,75.49 8.24,77.38 4.6,81.03 4.6,144.46 13.47,153.33 13.47,158.15 14.04,158.72 14.42,158.72 16.18,160.48 PCIE16X.B5 ; v2(166.35,15.56) 166.22,15.44 150.53,15.44 146.02,19.94 135.8,19.94 133.71,17.85 121.01,17.85 120.24,17.09 111.99,17.09 110.77,18.31 106.02,18.31 104.86,17.15 95.44,17.15 89.3,23.28 55.43,23.28 53.77,21.63 40.51,21.63 40.06,22.09 36.07,22.09 34.35,20.37 32.72,20.37 30.32,17.98 19.79,17.98 17.02,20.74 17.02,33.47 20.61,37.07 20.61,48.46 25.31,53.16 28.74,53.16 33.19,57.6 v2(35.37,57.6) 37.39,57.6 39.35,59.56 39.35,64.56 41.33,66.54 41.33,70.26 v2(40.84,70.74)
SMBCLK_STBY_IO: length 5.6
  TOP w0.102: R579.1 181.67,12.08 181.67,13.26 181.25,13.68 v1(181.25,14.07) C562.2 182.44,14.35 U35.60
SMBCLK_STBY_R: length 7.4
  TOP w0.089: R393.2 40.6,72.69 v2(40.6,73.5) 40.6,78.63 PCH1.AW44
  BOTTOM w0.102: v3(40.6,72.64) v2(40.6,73.5)
SMBDATA_MAIN: length 313.4
  TOP w0.102: Q43.S 51.28,53.85 51.54,53.6 R456.1 52.58,54.17 53.95,54.17 54.36,54.58 R455.1 55.09,54.93 54.71,55.31 54.71,56.33 v2(54.97,56.58) ; R595.1 122.97,12.65 119.81,15.82 115.16,15.82 112.37,18.61 v2(112.37,21.47) ; U4.29 v2(104.43,195.26) 103.93,194.76 R27.2 ; v2(69.86,83.65) 70.37,84.16 70.37,93.9 74.33,97.86 74.33,106.91 70.88,110.37 63.89,110.37 v2(63.32,109.8)
  BOTTOM w0.102: v2(104.43,195.26) 103.83,194.66 103.83,194.09 101.77,192.03 101.77,188.4 102.5,187.66 102.5,180.9 91.11,169.51 86.23,169.51 78.49,161.77 74.82,161.77 70.56,157.5 66.98,157.5 50.52,141.04 50.52,121.63 62.36,109.8 v2(63.32,109.8) ; v2(69.86,83.65) 69.86,81.72 71.16,80.42 71.16,70.56 59.21,58.62 57.38,58.62 55.35,56.58 v2(54.97,56.58) 54.51,56.58 51.73,53.8 51.73,38.74 53.6,36.87 53.6,35.61 54.19,35.02 56.58,35.02 57.19,34.41 81.51,34.41 v3(82.63,33.29) 86.92,33.29 91.42,28.8 91.42,26.62 96.21,21.82 112.01,21.82 v2(112.37,21.47)
SMBDATA_STBY: length 396.9
  TOP w0.089: R394.1 39.71,71.52
  TOP w0.102: R404.1 40.11,70.46 v2(40.11,70.76) 40.11,71.13 39.71,71.52 ; v2(166.35,14.8) 166.35,13.1 167.42,12.02 168.76,12.02 170.1,10.68 172.13,10.68 174.19,8.62 180.86,8.62 182.89,10.64 R580.2 ; Q43.D 48.2,54.7 45.53,54.7 44.75,53.92 36.04,53.92 34.52,55.44 v2(34.52,58.24) 34.52,59.68 33.53,60.67 31.55,60.67 30.51,59.63 28.29,59.63 27.97,59.95 23.94,59.95 21.74,62.15 15.49,62.15 10.14,67.51 10.14,67.91 v2(10.11,67.94)
  BOTTOM w0.102: PCIE16X.B6 13.24,158.62 13.24,153.43 4.37,144.56 4.37,80.93 8.01,77.29 8.01,75.4 11.28,72.13 11.28,70.75 11.48,70.54 11.48,69.95 10.97,69.44 10.4,69.44 9.88,68.91 9.88,68.17 v2(10.11,67.94) ; v2(40.11,70.76) 41.05,69.82 41.05,66.62 39.12,64.69 39.12,60.88 36.98,58.74 v3(35.54,58.74) 35.03,58.74 v2(34.52,58.24) 33.5,58.24 28.65,53.38 25.1,53.38 20.36,48.65 20.36,37.19 16.79,33.62 16.79,20.59 19.63,17.75 30.42,17.75 32.82,20.15 39.56,20.15 40.77,21.35 53.82,21.35 55.52,23.06 89.17,23.06 94.23,18 95.31,16.92 105.03,16.92 106.19,18.08 110.53,18.08 111.75,16.86 120.4,16.86 121.16,17.62 133.9,17.62 135.97,19.69 145.92,19.69 150.43,15.18 165.96,15.18 v2(166.35,14.8)
SMBDATA_STBY_IO: length 5.1
  TOP w0.102: R580.1 184.15,12.5 v1(184.15,12.97) 184.15,13.16 C563.2 182.84,14.47 U35.61
SMBDATA_STBY_R: length 6.9
  TOP w0.089: R394.2 v2(39.67,74.14) ; PCH1.BB43 39.49,78.91 v4(39.58,78.82)
  BOTTOM w0.102: v2(39.67,74.14) v3(39.67,75.48) 39.67,78.73 v4(39.58,78.82)
SMCLK_DIMM: length 17.1
  TOP w0.102: R447.2 C401.1 57.13,55.66 57.13,54.43 56.74,54.04 56.74,53.54 55.11,51.9 DIMM2.141 55.11,51.06 55.3,50.87 55.3,48.71 55.77,48.23 55.77,47.36 55.3,46.88 55.3,42.06 DIMM1.141
SMDATA_DIMM: length 18.5
  TOP w0.102: R455.2 C408.1 56.17,53.29 55.31,52.42 54.77,52.42 54.39,52.04 54.39,51.31 54.97,50.74 54.97,48.1 DIMM2.285 55.07,47.92 55.07,42.76 54.45,42.14 54.45,41.59 55.11,40.93 DIMM1.285
SML0_CLK: length 15.3
  TOP w0.089: PCH1.AY44 40.11,78.87 v4(40.11,79.38)
  TOP w0.102: R426.1 38.41,67.02 v2(38.93,67.02)
  BOTTOM w0.102: v2(38.93,67.02) 39.32,67.4 39.32,69.67 38.51,70.48 v3(38.51,71.75) 39.01,72.26 39.01,79.03 39.37,79.38 v4(40.11,79.38)
SML0_DATA: length 16
  TOP w0.089: v4(39,81.35) PCH1.BB39
  TOP w0.102: v2(37.33,67.94) 37.33,67.42 R425.1
  BOTTOM w0.102: v2(37.33,67.94) 36.68,68.59 36.68,75.08 v3(37.8,76.19) 38.23,76.62 38.23,79.88 39,80.65 v4(39,81.35)
SML0ALERT_L: length 1.6
  TOP w0.089: v4(40.43,80.96) PCH1.BA40
  BOTTOM w0.102: v4(40.43,80.96) 40.13,81.25 STP25.1
SML1_CLK: length 245.2
  TOP w0.089: v4(40.85,79.41) PCH1.AW42
  TOP w0.102: U35.28 170.98,18.9 171.62,19.54 v2(171.62,19.75) ; R428.2 40.74,67.73 v2(40.54,67.94)
  BOTTOM w0.102: v2(171.62,19.75) 170.94,19.75 168.63,17.44 168.63,15.56 167.31,14.24 151.01,14.24 145.81,19.44 136.08,19.44 134.03,17.39 127.47,17.39 125.63,15.55 122.29,15.55 121.21,16.63 95.28,16.63 89.08,22.83 55.61,22.83 53.91,21.13 40.93,21.13 39.68,19.87 32.92,19.87 30.57,17.52 19.52,17.52 16.56,20.48 16.56,33.71 20.1,37.26 20.1,48.84 24.88,53.61 28.55,53.61 34.73,59.78 v3(36.93,59.78) 38.53,61.38 38.53,64.43 40.54,66.43 v2(40.54,67.94) 40.54,69.13 39.6,70.07 39.6,73.3 40.85,74.55 v4(40.85,79.41)
SML1_DATA: length 252
  TOP w0.089: PCH1.AW45 41.36,77.89 41.36,71.52
  TOP w0.102: v2(43,66.64) 42.27,67.38 42.27,69.57 R406.2 41.36,70.47 41.36,71.52 ; U35.50 178.44,16.67 179.17,17.4 179.17,17.85 176.95,20.07 174.22,20.07 v2(173.9,19.75)
  BOTTOM w0.102: v2(43,66.64) 42.24,66.64 40.67,65.07 40.67,60.22 37.3,56.85 33.09,56.85 28.93,52.7 25.62,52.7 21.19,48.27 21.19,36.89 17.53,33.23 17.53,21 20.09,18.43 28.35,18.43 30.84,20.92 33.91,20.92 35.54,22.55 40.36,22.55 40.74,22.17 53.66,22.17 55.24,23.74 89.49,23.74 95.6,17.63 104.64,17.63 105.77,18.76 111.13,18.76 112.35,17.54 120,17.54 120.76,18.31 133.47,18.31 135.62,20.45 141.36,20.45 v3(141.78,20.87) 142.52,21.61 145.11,21.61 149.1,17.62 149.1,17.62 150.71,16.01 150.72,16.01 150.75,15.97 165.66,15.97 170.21,20.52 173.14,20.52 v2(173.9,19.75)
SML1ALERT_L: length 25.3
  TOP w0.089: PCH1.AT27 42.49,87.05 v4(42.49,86.95)
  TOP w0.102: R429.1 35.78,67.22 v2(35.28,66.72)
  BOTTOM w0.089: STP13.1 42.23,86.95 v4(42.49,86.95)
  BOTTOM w0.102: v2(35.28,66.72) 36.37,67.81 36.37,75.51 36.83,75.96 36.83,79.01 38.53,80.71 38.53,81.76 39.73,82.95 40.39,82.95 41.38,83.94 41.38,86.1 STP13.1
SPI0_IO2: length 14
  TOP w0.089: 32.02,78.48 32.79,78.48 34.77,80.46 34.77,81.07 35.48,81.78 35.48,84.39 37.28,86.19 37.6,86.19 37.69,86.28 38.62,86.28 38.76,86.42 PCH1.BC29
  TOP w0.102: 32.02,78.48 31.39,78.48 v4(31.09,78.17)
  BOTTOM w0.102: STP22.1 v4(31.09,78.17)
SPI0_IO3: length 5
  TOP w0.089: PCH1.BD30 38.48,85.78 38.35,85.65 38.17,85.65 38.14,85.62 37.68,85.62 36.42,84.37 v4(36.42,84.17)
  BOTTOM w0.089: STP18.1 37.64,84.93 36.88,84.17 v4(36.42,84.17)
SPI_CLK: length 25.2
  TOP w0.102: R383.1 31.04,74.81 v2(31.01,74.83) ; SPIROM1.6 30.77,58.36 30.48,58.07 v2(29.44,58.07)
  BOTTOM w0.102: v2(31.01,74.83) 31.01,73.73 29.69,72.41 29.69,68.49 arc(29.62,68.32) 29.45,68.25 29.02,68.25 arc(28.78,68.01) 29.02,67.77 29.45,67.77 arc(29.69,67.52) 29.45,67.28 29.02,67.28 arc(28.78,67.04) 29.02,66.8 29.45,66.8 arc(29.62,66.73) 29.69,66.56 29.69,64.86 27.74,62.91 27.74,60.83 29.34,59.23 v3(29.34,59.1) 29.34,58.17 v2(29.44,58.07)
SPI_CS_L0: length 50.9
  TOP w0.089: 32.02,71.85 33,71.85 33.41,72.27 33.41,72.94 34.27,73.79 34.27,78.07 36.3,80.11 36.3,82.75 37.03,83.48 37.03,84.23 38.04,85.24 PCH1.BD31
  TOP w0.102: v2(28.87,61.03) 29.35,61.51 30.24,61.51 30.9,62.17 34.28,62.17 38.74,57.71 38.74,55.54 39.28,55 41.57,55 42.46,55.89 C396.1 41.28,56.17 40.93,55.82 SPIROM1.1 ; 32.02,71.85 31.05,71.85 v2(30.84,71.63)
  BOTTOM w0.102: v2(28.87,61.03) 30.02,62.18 v3(30.02,64.08) 30.18,64.24 30.18,70.97 v2(30.84,71.63)
SPI_IO2_0: length 2.9
  TOP w0.102: SP19.2 42.14,59.44 41.06,58.36 SPIROM1.3
SPI_IO3_0: length 2.4
  TOP w0.102: SPIROM1.7 R449.2
SPI_MISO: length 43.2
  TOP w0.102: R380.2 31.5,75.63 v2(31.04,75.63) 30.36,75.63 R381.1 ; v2(29.69,61.03) 30.12,61.03 30.99,61.89 34.08,61.89 38.46,57.52 38.46,55.5 39.19,54.77 41.7,54.77 43.9,56.98 43.9,58.41 43.65,58.67 42.92,58.67 C391.1 42.14,58.24 41,57.09 SPIROM1.2
  BOTTOM w0.102: v2(31.04,75.63) 31.41,75.63 31.83,75.21 31.83,70.88 v3(31.45,70.5) 31.45,68.65 30.58,67.78 30.58,61.91 v2(29.69,61.03)
SPI_MISO_R: length 12.9
  TOP w0.089: PCH1.BE30 37.92,85.81 37.46,85.81 35.89,84.24 35.89,80.28 33.88,78.28 33.88,76.22 33.55,75.89 R380.1
SPI_MOSI: length 26
  TOP w0.102: v2(27.97,59.05) 28.27,59.35 29.24,59.35 C388.1 30.58,58.87 31.34,59.63 SPIROM1.5 ; R377.2 31.27,76.48 v2(31.04,76.48) 30.46,76.48 R378.1
  BOTTOM w0.102: v2(31.04,76.48) 30.73,76.48 30.07,75.82 30.07,74.06 29.17,73.15 29.17,72.54 28.25,71.62 28.25,66.64 27.41,65.8 27.41,63.26 27.25,63.11 27.25,60.11 v3(27.46,59.91) 27.97,59.4 v2(27.97,59.05)
SPI_MOSI_R: length 13.4
  TOP w0.089: R377.1 33.25,76.97 33.69,77.41 33.69,78.37 35.69,80.36 35.69,84.33 37.36,86 37.68,86 37.77,86.09 38.8,86.09 38.9,86.2 39.02,86.2 39.13,86.31 39.21,86.39 PCH1.BB29
SPI_WP: length 4.8
  TOP w0.102: SP19.1 R438.1 R442.2 44.52,57.45 44.93,57.04 44.93,56.14
SRTCRST_L: length 11.5
  TOP w0.089: R358.2 32.65,92.72 32.49,92.87 C342.1 34.08,95.2 38.73,95.2 38.81,95.28 39.01,95.28 39.22,95.49 PCH1.BB10
SUS_1P0A: length 1.9
  TOP w0.254: Q84.5 Q84.6 13.74,33.33 R618.2
SUSACK_L: length 264
  TOP w0.089: 32.02,79.39 32.51,79.39 33.93,80.82 33.93,81.35 34.67,82.08 34.67,84.66 34.85,84.83 34.85,86.3 37,88.45 37,90.06 37.57,90.64 38.67,90.64 38.77,90.73 39,90.73 39.21,90.94 PCH1.BB19
  TOP w0.102: v2(23.83,61.8) 24.96,60.67 28.22,60.67 28.57,60.32 30.15,60.32 31.27,61.44 33.86,61.44 36.81,58.49 v2(36.81,55.7) ; R519.1 R513.2 v2(165.77,25.98) R512.1 ; 32.02,79.39 29.69,79.39 28.3,78 28.3,71.44 25.96,69.11 25.96,68.14 25.22,67.4 25.22,67.35 23.9,66.03 v2(23.48,66.03)
  BOTTOM w0.102: v2(165.77,25.98) 164.88,25.98 162.15,23.25 v3(148.95,23.25) 146.5,23.25 145.62,22.37 136.26,22.37 133.54,19.65 131.14,19.65 130.79,20.01 129.28,20.01 128.27,18.99 120.47,18.99 119.71,18.23 113.54,18.23 111.42,20.35 102.51,20.35 102.01,19.86 100.27,19.86 100.1,20.02 94.89,20.02 93.98,20.94 93.98,22.37 92.37,23.98 91.16,23.98 90.48,24.66 54.86,24.66 53.38,23.18 41.12,23.18 40.84,23.46 34.9,23.46 33.4,21.96 30.47,21.96 27.85,19.35 20.59,19.35 18.47,21.47 18.47,32.79 22.35,36.68 22.35,39.35 22.95,39.95 22.95,45.36 22.58,45.73 22.58,48.12 26.22,51.76 29.34,51.76 32.77,55.19 36.3,55.19 v2(36.81,55.7) ; v2(23.48,66.03) 24.31,65.21 24.31,62.29 v2(23.83,61.8)
SUSACK_L_R: length 3
  TOP w0.102: U35.13 169.3,24.9 168.81,25.39 v1(168.48,25.39) 167.98,24.9 R519.2
SUSCLK: length 1.5
  TOP w0.089: PCH1.AN15 43.68,93.22 v4(43.32,92.86)
  BOTTOM w0.089: v4(43.32,92.86) 43.1,92.64 STP10.1
SUSWARN_L: length 332.6
  TOP w0.089: 32.02,79.62 32.46,79.62 33.73,80.89 33.73,81.42 34.47,82.15 34.47,84.72 34.66,84.91 34.66,86.39 36.74,88.47 36.74,90.11 37.65,91.02 38.19,91.02 38.24,91.06 PCH1.BD19
  TOP w0.102: v2(182.79,17.85) 181.52,19.12 179.75,19.12 177.27,21.6 174.92,21.6 171.21,25.3 U35.12 169.33,25.3 168.66,25.98 R513.1 R511.1 ; 32.02,79.62 29.57,79.62 28.04,78.1 28.04,71.54 25.73,69.23 25.73,68.24 24.06,66.57 13.11,66.57 12.68,67 12.68,68.01 v2(11.66,69.03)
  BOTTOM w0.102: v2(182.79,17.85) v3(182.79,16.26) 182.79,15.66 185.42,13.04 185.42,10 177.45,2.03 65.52,2.03 64.1,3.45 61.88,3.45 60.47,2.03 4.3,2.03 2.29,4.04 2.29,54.2 10.68,62.59 10.68,68.32 11.39,69.03 v2(11.66,69.03)
