# Allegro board ECS H11H4-AI-V1.0-OK.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_DQS_B_P6: length 90
  TOP w0.089: v4(111.3,105.05) CPU.AL8
  GND w0.089: 102.2,100.51 102.22,100.52 102.28,100.52 103.31,101.55 104.26,101.55 106.35,103.63 109.71,103.63 110.83,104.75 111.01,104.75 v4(111.3,105.05)
  GND w0.14: 102.2,100.51 94.37,92.67 94.37,78.97 93.1,77.7 93.1,72.8 92.53,72.23 92.53,72.21 72.81,52.48 72.81,51.4 71.92,50.51 71.92,49.47 71.12,48.67 71.12,47.61 71.97,46.76 71.97,45.78 71.13,44.94 71.13,41.61 70.27,40.74 70.27,39.51 71.13,38.65 71.13,37.76 70.82,37.45 70.58,37.45 70.41,37.62 DIMM1.267
M_DQS_B_P7: length 102.6
  TOP w0.089: v4(109.47,108.7) CPU.AG7
  GND w0.089: 102,106.87 102.05,106.82 103.16,106.82 103.5,107.16 104.19,107.16 105.44,108.41 106.66,108.41 107.44,109.19 108.99,109.19 v4(109.47,108.7)
  GND w0.14: 102,106.87 100,106.87 88.14,95 88.14,90.61 86.3,88.77 arc(86.13,88.35) 86.3,87.93 86.57,87.66 arc(86.66,87.44) 86.57,87.21 arc(86.35,87.12) 86.12,87.21 85.85,87.48 arc(85.01,87.48) 85.01,86.64 85.28,86.37 arc(85.37,86.15) 85.28,85.92 arc(85.05,85.83) 84.83,85.92 84.56,86.19 arc(83.72,86.19) 83.72,85.34 83.98,85.08 arc(84.08,84.85) 83.98,84.63 78.44,79.08 78.44,66.86 64.3,52.72 64.3,51.35 63.46,50.51 63.46,49.33 62.63,48.5 62.63,47.5 63.46,46.67 63.46,45.6 62.62,44.76 62.62,41.54 61.73,40.66 61.73,39.89 60.92,39.08 60.92,37.44 61.06,37.3 DIMM1.278
M_DQS_B_P8: length 78.2
  TOP w0.089: CPU.AN25 v4(128.13,102.3)
  GND w0.089: v4(128.13,102.3) 128.15,102.3 128.96,101.86 129.16,101.86 129.43,101.59 129.43,96.93 131.27,95.09 131.27,94.87 132.99,93.33 133.03,93.27 133.47,92.61 134.39,91.26 135.46,88.47 135.55,87.83 135.5,87.62
  GND w0.14: 135.5,87.62 135.5,84.86 137.3,83.06 137.3,76.25 137.57,75.98 137.57,69.33 arc(137.75,68.9) 138.17,68.73 138.55,68.73 arc(138.87,68.41) 138.55,68.09 138.17,68.09 arc(137.57,67.5) 138.17,66.9 138.55,66.9 arc(138.87,66.58) 138.55,66.27 138.17,66.27 arc(137.57,65.67) 138.17,65.07 138.53,65.07 138.84,64.75 138.84,54.36 137.72,53.24 137.72,52.78 137.39,52.44 137.39,51.27 138.26,50.4 138.26,49.43 139.08,48.61 139.08,47.65 138.29,46.86 138.29,46.13 136.35,44.2 136.35,43.65 135.75,43.04 135.75,41.57 134.91,40.73 134.91,39.38 135.72,38.57 135.72,37.69 135.52,37.48 135.17,37.48 135,37.65 DIMM1.197
M_MA_A0: length 58.4
  TOP w0.089: CPU.AW15 119.6,96.21 119.6,95.97 119.5,95.87 119.29,95.87 119.08,95.66 119.08,94.51
  TOP w0.216: DIMM2.79 108.23,52.19 108.23,52.53 111.78,56.09 111.78,57.26 116.86,62.34 116.86,67.97 arc(117.05,68.16) 117.24,67.97 117.24,64.06 arc(117.43,63.87) 117.62,64.06 117.62,92.5 119.08,93.95 119.08,94.51
M_MA_A1: length 62.4
  TOP w0.089: CPU.AU18 122.77,97.61 122.77,97 123.02,96.74 123.02,96.07 123.53,95.57 123.53,93.9 121.22,91.6 121.22,90.44
  TOP w0.165: 119.63,53.27 119.63,52.9 118.99,52.25 118.99,51.13 118.67,50.82 118.67,50.34 DIMM2.72
  TOP w0.216: 121.22,90.44 121.22,81.45 121.98,80.69 121.98,72.63 arc(121.79,72.44) 121.6,72.63 121.6,77.73 arc(121.41,77.92) 121.22,77.73 121.22,57.94 119.63,56.35 119.63,53.27
M_MA_A2: length 61.2
  TOP w0.089: 120.84,90.44 120.84,91.65 123.3,94.11 123.3,95.48 122.79,95.98 122.79,96.65 122.52,96.92 122.52,97.49 122.23,97.78 121.68,97.78 CPU.AU17
  TOP w0.165: 119.16,53.3 119.16,53.28 118.69,52.81 118.69,51.25 117.97,50.53 117.97,49.48 118.69,48.76 118.69,46.52 DIMM2.216
  TOP w0.216: 119.16,53.3 119.16,53.64 arc(119.11,53.78) 118.97,53.83 118.85,53.83 arc(118.66,54.02) 118.85,54.21 118.97,54.21 arc(119.11,54.27) 119.16,54.41 119.16,56.42 120.84,58.1 120.84,80.23 arc(121.03,80.42) 121.22,80.23 121.22,78.53 arc(121.41,78.34) 121.6,78.53 121.6,80.53 120.84,81.3 120.84,90.44
M_MA_A3: length 62.3
  TOP w0.089: 121.6,90.44 121.6,91.54 123.74,93.68 123.74,95.67 123.25,96.16 123.25,96.87 123.16,96.96 123.16,97.22 CPU.AV19
  TOP w0.216: DIMM2.71 120.01,52.07 120.01,56.16 121.6,57.74 121.6,71.87 arc(121.79,72.06) 121.98,71.87 121.98,65.18 arc(122.17,64.98) 122.36,65.18 122.36,80.85 121.6,81.61 121.6,90.44
M_MA_A4: length 63.3
  TOP w0.089: 121.98,90.44 121.98,91.49 123.98,93.49 123.98,95.74 123.49,96.23 123.49,96.95 123.44,97 123.44,97.61 123.27,97.78 122.98,97.78 122.61,98.16 122.61,98.9 122.81,99.1 CPU.AT19
  TOP w0.165: DIMM2.214 120.01,46.36 119.01,47.36 119.01,48.61 119.8,49.39 119.8,50.69 120.39,51.29 120.39,52.89
  TOP w0.216: 121.98,90.44 121.98,81.77 122.74,81.01 122.74,61.96 arc(122.55,61.77) 122.36,61.96 122.36,64.41 arc(122.17,64.6) 121.98,64.41 121.98,57.58 120.39,56 120.39,53.12 120.39,52.89
M_MA_A5: length 63.7
  TOP w0.089: 122.36,90.44 122.36,91.44 124.23,93.31 124.23,95.79 123.73,96.28 123.73,96.94 123.68,97 123.68,97.55 124.02,97.89 CPU.AU20
  TOP w0.165: DIMM2.213 121.32,48.04 121.32,50.65 120.71,51.26 120.71,52.16 121.02,52.47 121.02,53.27
  TOP w0.216: 121.02,53.27 121.02,56.03 122.36,57.37 122.36,61.19 arc(122.55,61.38) 122.74,61.19 122.74,58.49 arc(122.93,58.3) 123.12,58.49 123.12,84.08 arc(122.93,84.27) 122.74,84.08 122.74,82.3 arc(122.55,82.11) 122.36,82.3 122.36,90.44
M_MA_A6: length 62.3
  TOP w0.089: 122.8,90.44 122.8,91.45 124.46,93.11 124.46,95.87 124.02,96.31 CPU.AV20
  TOP w0.165: 121.4,53.3 DIMM2.69
  TOP w0.216: 122.8,90.44 122.8,84.84 arc(122.99,84.65) 123.18,84.84 123.18,89.69 arc(123.37,89.88) 123.56,89.69 123.56,81.54 124.27,80.83 124.27,79.26 arc(124.08,79.07) 123.89,79.26 123.89,80.59 arc(123.7,80.78) 123.51,80.59 123.51,57.91 121.4,55.8 121.4,53.3
M_MA_A7: length 63.9
  TOP w0.089: CPU.AU21 124.93,97.97 124.59,97.64 124.59,96.91 124.51,96.82 124.51,96.46 124.94,96.02 124.94,92.7 124.33,92.09 124.33,90.87
  TOP w0.165: DIMM2.211 122.94,48.12 122.94,50.68 122.41,51.21 122.41,52.46 122.32,52.55 122.32,52.9
  TOP w0.216: 122.32,52.9 122.32,55.64 124.32,57.64 124.32,72.76 arc(124.51,72.95) 124.7,72.76 124.7,67.57 arc(124.89,67.38) 125.08,67.57 125.08,81.09 124.33,81.84 124.33,90.87
M_MA_A8: length 62.1
  TOP w0.089: 123.95,90.87 123.95,92.14 124.7,92.89 124.7,95.93 124.26,96.38 124.26,96.9 124.35,97 124.35,98 124.44,98.08 124.44,98.69 CPU.AT20
  TOP w0.165: 121.94,52.58 121.94,52.36 122.09,52.2 122.09,50.32 DIMM2.68
  TOP w0.216: 121.94,52.58 121.94,55.8 123.89,57.75 123.89,78.49 arc(124.08,78.69) 124.27,78.49 124.27,73.52 arc(124.46,73.33) 124.65,73.52 124.65,80.99 123.95,81.68 123.95,90.87
M_MA_A9: length 66
  TOP w0.089: CPU.AT22 126.18,98.77 126.18,97.97 125.98,97.77 125.78,97.77 125.51,97.49 125.51,97.06 125.62,96.94 125.62,96.36 125.43,96.16 125.43,92.32 125.11,92.01 125.11,90.87
  TOP w0.165: 124.18,53.3 124.18,52.12 124.11,52.05 124.11,50.32 DIMM2.66
  TOP w0.216: 124.18,53.3 124.18,56.17 arc(124.37,56.36) 124.56,56.17 124.56,53.15 arc(124.75,52.96) 124.94,53.15 124.94,57.17 125.09,57.32 125.09,61.69 arc(125.28,61.88) 125.47,61.69 125.47,60.77 arc(125.66,60.58) 125.85,60.77 125.85,80.4 arc(126.05,80.59) 126.24,80.4 126.24,78.39 arc(126.43,78.2) 126.62,78.39 126.62,80.64 125.11,82.14 125.11,90.87
M_MA_A10: length 59.6
  TOP w0.089: CPU.AY14 117.98,94.9
  TOP w0.165: DIMM2.225 105.95,48.12 105.95,50.59 106.79,51.44 106.79,51.47 106.8,51.47 106.8,52.83
  TOP w0.216: 106.8,52.83 106.8,53.32 111,57.53 111,57.55 116.1,62.65 116.1,73.15 arc(116.29,73.34) 116.48,73.15 116.48,70.16 arc(116.67,69.97) 116.86,70.16 116.86,92.88 117.98,94 117.98,94.9
M_MA_A11: length 63.8
  TOP w0.089: CPU.AU22 125.55,98.19 125.27,97.9 125.27,96.91 125.36,96.82 125.36,96.46 125.18,96.29 125.18,92.51 124.72,92.05 124.72,90.87
  TOP w0.165: DIMM2.210 124.37,46.78 124.37,47.24 123.95,47.66 123.95,48.88 123.26,49.57 123.26,50.7 123.79,51.23 123.79,52.31 123.69,52.42 123.69,53.3
  TOP w0.216: 124.72,90.87 124.72,81.99 125.46,81.25 125.46,62.57 arc(125.27,62.38) 125.08,62.57 125.08,66.81 arc(124.89,67) 124.7,66.81 124.7,57.48 123.69,56.48 123.69,53.3
M_MA_A12: length 61.9
  TOP w0.089: 125.57,90.97 125.57,92.01 125.67,92.11 125.67,96.05 125.91,96.28 125.91,97.21 CPU.AV22
  TOP w0.165: DIMM2.65 124.8,52.06 125.32,52.58 125.32,53.3
  TOP w0.216: 125.32,53.3 125.32,56.78 125.47,56.93 125.47,59.75 126.24,60.51 126.24,77.63 arc(126.43,77.82) 126.62,77.63 126.62,70.72 arc(126.81,70.53) 127,70.72 127,80.79 125.57,82.22 125.57,90.97
M_MA_A13: length 58.9
  TOP w0.089: 114.45,95.74 114.89,96.18 114.99,96.18 115.69,96.88 116.31,96.88 CPU.AV12
  TOP w0.165: DIMM2.232 100.15,48.48 99.3,49.33 99.3,50.57 100.16,51.43 100.16,52.07
  TOP w0.216: 100.16,52.07 113.23,65.14 113.23,83.73 113.98,84.48 113.98,95.27 114.45,95.74
M_MA_A14: length 61.8
  TOP w0.089: 115.72,93.61 116.42,94.31 116.8,94.31 117.04,94.55 117.04,95.86 117.2,96.02 117.2,96.53 117.48,96.82 118.07,96.82 CPU.AV14
  TOP w0.165: DIMM2.228 103.55,48.52 104.4,49.37 104.4,50.55 103.71,51.24 103.71,52.05 104.83,53.17 104.93,53.17 105.06,53.3
  TOP w0.216: 115.72,93.61 115.72,83.78 114.96,83.02 114.96,64.42 112.03,61.5 arc(111.97,61.34) 112.03,61.19 arc(112.18,61.13) 112.33,61.19 113.21,62.07 arc(113.52,62.07) 113.52,61.76 105.06,53.3
M_MA_A15: length 57.9
  TOP w0.089: 115.17,94.94 115.68,95.45 CPU.AY11
  TOP w0.216: DIMM2.86 101.85,52.53 107.29,57.97 arc(107.56,57.97) 107.56,57.7 105.7,55.84 arc(105.7,55.57) 105.97,55.57 111.01,60.61 111.01,61.7 114.09,64.78 114.09,83.37 114.86,84.14 114.86,94.62 115.17,94.94
M_MA_A16: length 59
  TOP w0.089: 116.1,93.02 116.1,93.15 117.26,94.31 117.26,95.76 117.62,96.12 CPU.AW13
  TOP w0.216: 116.1,93.02 116.1,79.95 arc(115.91,79.76) 115.72,79.95 115.72,82.42 arc(115.53,82.61) 115.34,82.42 115.34,64.27 114.01,62.94 arc(114.01,62.61) 114.34,62.61 114.62,62.9 arc(114.95,62.9) 114.95,62.57 110.23,57.86 110.23,57.85 105.69,53.3 105.25,52.86 DIMM2.82
M_MA_B0: length 79.4
  TOP w0.089: CPU.AL19 v4(122.64,104.13)
  GND w0.089: v4(122.64,104.13) 122.78,103.9 123.08,103.39 123.08,103.04 122.77,102.73 122.49,102.73 122.26,102.49 122.26,101.44 122.69,101.01 122.69,94.25 122.38,93.95 122.38,92.8
  GND w0.178: DIMM1.79 107.97,42.03 107.97,44.19 108.28,44.5 108.28,45.48 107.97,45.8 107.97,46.65 108.82,47.51 108.82,48.43 107.97,49.28 107.97,50.45 108.61,51.09 109.11,51.09 110.34,52.32 arc(110.43,52.49) 110.37,52.67 110.07,52.97 arc(110.07,53.29) 110.39,53.29 110.69,52.99 arc(111.02,52.99) 111.02,53.32 110.72,53.62 arc(110.72,53.94) 111.04,53.94 111.34,53.64 arc(111.66,53.64) 111.66,53.96 111.36,54.26 arc(111.36,54.59) 111.69,54.59 111.99,54.29 arc(112.31,54.29) 112.31,54.61 112.01,54.91 arc(112.01,55.23) 112.33,55.23 112.63,54.93 arc(112.96,54.93) 112.96,55.26 112.66,55.56 arc(112.59,55.72) 112.66,55.88 114.47,57.7 arc(114.63,57.76) 114.8,57.7 115.11,57.39 arc(115.43,57.39) 115.43,57.71 115.12,58.02 arc(115.12,58.34) 115.44,58.34 115.75,58.03 arc(115.91,57.97) 116.07,58.02 119,60.95 119,87.38 122.38,90.76 122.38,92.8
M_MA_B1: length 80.3
  TOP w0.089: CPU.AL22 v4(126.3,104.13)
  GND w0.089: 126.27,92.8 126.27,93.38 127.24,94.35 127.24,94.7 126.68,95.26 126.68,97.76 126.42,98.01 126.42,99.18 126.58,99.33 126.58,101.82 126.73,102.17 126.73,103.7 v4(126.3,104.13)
  GND w0.178: 126.27,92.8 126.27,89.37 123.6,86.7 123.6,59.73 arc(123.37,59.51) 123.14,59.73 123.14,64.56 arc(122.91,64.79) 122.68,64.56 122.68,58.72 120.14,56.17 120.14,54.26 118.69,52.8 118.69,52.18 118.69,52.18 118.69,51.91 118.69,51.91 118.69,51.31 118.17,50.79 118.17,48.83 118.69,48.3 118.69,47.29 118.17,46.77 118.17,42.82 118.78,42.21 118.78,40.34 DIMM1.72
M_MA_B2: length 78.7
  TOP w0.089: CPU.AM22 v4(126.3,103.22)
  GND w0.089: v4(126.3,103.22) 126.24,103.22 125.8,102.78 125.8,102.19 126.37,101.63 126.37,99.48 126.22,99.34 126.22,97.78 126.36,97.63 126.36,94.99 125.81,94.44 125.81,92.8
  GND w0.178: DIMM1.216 118.85,38.94 118.02,39.78 118.02,40.79 117.26,41.56 117.26,42.61 117.84,43.19 117.84,46.65 117.26,47.23 117.26,48.23 117.84,48.81 117.84,50.48 117.26,51.06 117.26,52.3 119.68,54.73 119.68,56.38 122.23,58.92 122.23,67.67 arc(122.45,67.9) 122.68,67.67 122.68,65.52 arc(122.91,65.3) 123.14,65.52 123.14,86.89 125.81,89.56 125.81,92.8
M_MA_B3: length 78.1
  TOP w0.089: CPU.AM23 v4(127.22,102.3)
  GND w0.089: v4(127.22,102.3) 127.22,102 126.79,101.57 126.79,99.16 126.63,99 126.63,98.19 126.97,97.85 126.97,95.42 127.61,94.78 127.61,94.19 126.73,93.31 126.73,92.93
  GND w0.178: DIMM1.71 119.04,42.53 119.04,45.15 119.54,45.65 119.54,46.72 119.02,47.24 119.02,48.31 119.54,48.83 119.54,50.83 119.02,51.36 119.02,52.49 120.6,54.07 120.6,55.9 124.13,59.43 124.13,85.52 arc(124.36,85.75) 124.59,85.52 124.59,80.21 arc(124.82,79.98) 125.04,80.21 125.04,87.5 126.73,89.18 126.73,92.93
M_MA_B4: length 77.4
  TOP w0.089: v4(127.24,100.48) 126.79,100.93 CPU.AP23
  GND w0.089: v4(127.24,100.48) 127.03,100.26 127.03,99.05 126.83,98.84 126.83,98.45 127.26,98.01 127.26,95.58 127.89,94.96 127.89,93.97 127.19,93.27 127.19,92.96
  GND w0.178: 127.19,92.96 127.19,88.99 125.5,87.31 125.5,76.04 arc(125.27,75.81) 125.04,76.04 125.04,79.12 arc(124.82,79.35) 124.59,79.12 124.59,59.22 121.05,55.69 121.05,53.71 120.39,53.04 120.39,51.22 119.87,50.7 119.87,48.9 120.39,48.38 120.39,47.22 119.87,46.69 119.87,45.35 119.48,44.96 119.48,43.57 120.39,42.66 120.39,41.36 119.69,40.67 119.69,39.75 120.55,38.9 DIMM1.214
M_MA_B5: length 79.8
  TOP w0.089: CPU.AL23 v4(127.22,103.22)
  GND w0.089: v4(127.22,103.22) 127.67,102.76 127.67,100.31 127.3,99.93 127.3,99.47 127.67,99.1 127.67,98.06 127.55,97.95 127.55,95.76 128.16,95.16 128.16,93.75 127.64,93.24 127.64,92.93
  GND w0.178: DIMM1.213 121.4,40.59 120.72,41.27 120.72,42.18 120.87,42.34 120.87,45.21 121.24,45.58 121.24,46.72 120.72,47.24 120.72,49 121.24,49.53 121.24,50.5 120.72,51.03 120.72,52.72 121.51,53.52 121.51,55.5 125.04,59.03 125.04,75.12 arc(125.27,75.35) 125.5,75.12 125.5,71.14 arc(125.73,70.91) 125.96,71.14 125.96,87.12 127.64,88.8 127.64,92.93
M_MA_B6: length 70.5
  TOP w0.089: v4(129.04,94.06) 128.93,94.2 128.93,95.8 129.49,96.36 CPU.AW26
  GND w0.178: DIMM1.69 121.4,44.77 121.56,44.94 121.56,46.74 122.09,47.26 122.09,48.44 121.56,48.96 121.56,50.6 122.09,51.13 122.09,55.43 124.69,58.04 arc(125.02,58.04) 125.02,57.71 123.61,56.31 arc(123.61,55.98) 123.94,55.98 125.53,57.58 125.53,70.22 arc(125.76,70.45) 125.98,70.22 125.98,67.58 arc(126.21,67.35) 126.44,67.58 126.44,86.95 128.1,88.61 128.1,93.12 v4(129.04,94.06)
M_MA_B7: length 69.8
  TOP w0.089: CPU.AY26 129.49,95.43 129.49,94.51 129.77,94.22 129.77,93.01 129.52,92.75 129.52,92.19 v4(129.3,91.98)
  GND w0.178: DIMM1.211 122.94,38.23 122.94,40.83 122.41,41.35 122.41,44.66 123.26,45.51 123.26,46.72 123.79,47.24 123.79,48.32 123.26,48.84 123.26,50.55 123.79,51.07 123.79,52.73 124.46,53.41 124.46,54.88 126.44,56.86 126.44,61.13 arc(126.67,61.35) 126.9,61.13 126.9,57.4 arc(127.13,57.17) 127.36,57.4 127.36,86.58 129.01,88.23 129.01,91.69 v4(129.3,91.98)
M_MA_B8: length 72.7
  TOP w0.089: CPU.AU26 129.5,97.8 129.84,97.47 129.84,96.09 129.64,95.89 129.38,95.89 129.17,95.68 129.17,94.53 129.47,94.23 129.47,93.07 v4(129.04,92.64)
  GND w0.178: v4(129.04,92.64) 128.56,92.16 128.56,88.42 126.9,86.77 126.9,62.07 arc(126.67,61.84) 126.44,62.07 126.44,66.61 arc(126.21,66.84) 125.98,66.61 125.98,57.05 124,55.07 124,53.83 122.41,52.24 122.41,51.05 122.94,50.53 122.94,48.88 122.41,48.36 122.41,47.22 122.94,46.69 122.94,45.69 122.09,44.84 122.09,40.43 DIMM1.68
M_MA_B9: length 69.8
  TOP w0.089: 129.36,89.78 129.46,89.87 129.82,89.87 130.21,90.27 130.21,91.29 130.1,91.4 130.1,92.44 130.37,92.72 130.37,94.23 130.24,94.36 130.24,94.36 129.99,94.61 129.99,94.96 130.08,95.05 130.08,95.64 130.42,95.97 CPU.AW27
  TOP w0.216: v4(129.49,86.07) 129.09,86.48 129.09,89.5 129.36,89.78
  GND w0.178: v4(129.49,86.07) 129.16,86.07 128.27,85.18 128.27,60.01 arc(128.5,59.78) 128.73,60.01 128.73,61.84 arc(128.96,62.07) 129.18,61.84 129.18,57.45 127.95,56.22 127.32,56.22 125.5,54.39 arc(125.5,54.07) 125.82,54.07 126.74,54.99 arc(127.06,54.99) 127.06,54.66 125.49,53.09 125.49,51.48 125.18,51.17 125.18,50.69 124.96,50.47 124.96,48.79 125.49,48.27 125.49,47.2 124.96,46.68 124.96,45.11 124.11,44.26 124.11,40.43 DIMM1.66
M_MA_B10: length 77.3
  TOP w0.089: v4(121.72,100.48) 122.18,100.93 CPU.AP18
  GND w0.089: 121.39,92.8 121.39,96.49 121.33,96.55 121.33,97 121.62,97.29 121.62,98.18 121.33,98.47 121.33,100.09 v4(121.72,100.48)
  GND w0.178: 121.39,92.8 121.39,91.06 117.17,86.84 117.17,84.91 arc(117.4,84.68) 117.63,84.91 117.63,86.51 arc(117.86,86.73) 118.09,86.51 118.09,62.7 arc(118.07,62.61) 118.02,62.54 117.78,62.3 arc(117.71,62.14) 117.78,61.98 117.99,61.77 arc(117.99,61.44) 117.67,61.44 117.46,61.65 arc(117.3,61.72) 117.13,61.65 108.23,52.75 107.82,52.75 107.12,52.05 107.12,51.31 106.27,50.46 106.27,49.84 107.12,48.99 107.12,47.53 106.27,46.68 106.27,45.91 106.79,45.39 106.79,41.37 106.1,40.69 DIMM1.225
M_MA_B11: length 73.3
  TOP w0.089: v4(129.74,90.4) 129.31,90.83 129.31,91.29 129.79,91.77 129.79,92.62 130.09,92.93 130.09,94.21 129.75,94.56 129.75,95.09 129.84,95.18 129.84,95.76 130.08,96 130.08,97.47 130.42,97.8 CPU.AU27
  GND w0.178: DIMM1.210 123.95,38.67 123.26,39.36 123.26,40.88 123.79,41.4 123.79,42.18 123.38,42.58 123.37,42.58 123.37,44.47 124.64,45.74 124.64,46.67 124.11,47.2 124.11,48.25 124.64,48.77 124.64,50.59 124.11,51.11 124.11,52.33 124.94,53.16 124.94,54.57 127.04,56.67 127.76,56.67 128.73,57.64 128.73,59.07 arc(128.5,59.3) 128.27,59.07 128.27,57.96 arc(128.04,57.73) 127.81,57.96 127.81,86.39 128,86.57 arc(128.16,86.64) 128.32,86.57 128.5,86.4 arc(128.82,86.4) 128.82,86.72 128.65,86.9 arc(128.65,87.22) 128.97,87.22 129.15,87.04 arc(129.47,87.04) 129.47,87.37 129.29,87.54 arc(129.23,87.7) 129.29,87.87 129.47,88.04 129.47,90.14 v4(129.74,90.4)
M_MA_B12: length 73
  TOP w0.089: CPU.AV27 130.42,96.91 130.75,96.58 130.75,95.09 130.86,94.99 130.86,94.6 130.72,94.47 130.72,92.59 130.42,92.29 130.42,90.14 129.74,89.45
  TOP w0.216: v4(129.65,84.62) 129.68,84.65 129.72,84.65 130.15,85.08 130.15,87 129.58,87.57 129.58,89.3 129.74,89.45
  GND w0.178: DIMM1.65 124.8,44.36 126.34,45.89 126.34,46.8 125.81,47.32 125.81,48.29 126.34,48.82 126.34,50.59 125.81,51.11 125.81,52.07 128.4,54.65 128.4,55.97 130.56,58.13 130.56,59.71 arc(130.33,59.94) 130.1,59.71 130.1,58.64 arc(129.87,58.41) 129.64,58.64 129.64,66.67 arc(129.41,66.9) 129.18,66.67 129.18,62.8 arc(128.96,62.57) 128.73,62.8 128.73,83.81 129.54,84.62 v4(129.65,84.62)
M_MA_B13: length 74.6
  TOP w0.089: CPU.AR15 v4(118.99,100.48)
  GND w0.089: 117.68,94.43 117.68,94.9 118.6,95.83 118.6,97.65 119.4,98.45 119.4,99.67 119.28,99.9 119.15,100.15 v4(118.99,100.48)
  GND w0.178: 117.68,94.43 117.68,92.25 113.74,88.32 113.74,81.98 114.36,81.36 114.36,80.81 114.37,80.81 114.37,74.34 114.36,74.34 114.36,71.33 113.74,70.71 113.74,64.23 101.69,52.18 101.69,51.48 100.87,50.66 100.87,49.28 101.73,48.42 101.73,47.68 100.85,46.8 100.85,45.99 100.18,45.32 100.18,41.49 99.35,40.67 99.35,39.61 100.15,38.8 DIMM1.232
M_MA_B14: length 79.5
  TOP w0.089: CPU.AL17 v4(120.82,104.13)
  GND w0.089: 119.87,93.18 119.87,94.84 120.12,95.09 120.12,96.04 120.61,98.14 120.61,100.6 121.22,101.21 121.22,103.73 v4(120.82,104.13)
  GND w0.178: DIMM1.228 103.55,38.77 104.43,39.65 104.43,40.58 103.69,41.32 103.69,45.2 104.24,45.75 104.24,46.82 105.09,47.67 105.09,48.58 104.24,49.43 104.24,50.31 104.24,50.58 105.09,51.45 105.09,52.54 107.73,55.18 arc(107.89,55.27) 108.07,55.2 108.2,55.07 arc(108.52,55.07) 108.52,55.4 108.39,55.53 arc(108.39,55.85) 108.72,55.85 108.85,55.72 arc(109.17,55.72) 109.17,56.04 109.04,56.17 arc(108.97,56.37) 109.09,56.54 116.71,64.16 116.71,81.89 115.8,82.81 115.8,87.44 119.87,91.51 119.87,93.18
M_MA_B15: length 76.3
  TOP w0.089: CPU.AP16 v4(119.9,100.48)
  GND w0.089: v4(119.9,100.48) 119.9,97.99 119.31,97.09 119.31,95.49 118.82,95 118.82,94.09
  GND w0.178: 118.82,94.09 118.82,91.96 114.78,87.92 114.78,82.38 115.67,81.5 115.67,64.8 arc(115.44,64.57) 115.21,64.8 115.21,67.57 arc(114.99,67.8) 114.76,67.57 114.76,63.65 103.39,52.29 103.39,51.4 102.54,50.55 102.54,49.35 103.39,48.5 103.39,47.67 102.55,46.83 102.55,45.49 101.89,44.83 101.89,40.3 DIMM1.86
M_MA_B16: length 78.1
  TOP w0.089: CPU.AN18 121.73,102.3 v4(121.73,103.22)
  GND w0.089: 120.43,93.8 120.43,93.98 120.76,94.31 120.76,95.14 120.68,95.22 120.68,95.57 120.85,97.75 120.85,100.52 121.47,101.15 121.47,102.72 v4(121.73,103.22)
  GND w0.178: DIMM1.82 105.25,42.39 104.57,43.08 104.57,46.68 105.42,47.53 105.42,48.95 104.57,49.8 104.57,50.45 105.42,51.3 105.42,52.21 106.13,52.93 106.63,52.93 107.16,53.46 107.16,53.96 107.76,54.55 108.68,54.55 110.2,56.07 arc(110.27,56.23) 110.2,56.39 110.06,56.53 arc(110.06,56.86) 110.38,56.86 110.52,56.71 arc(110.85,56.71) 110.85,57.04 110.7,57.18 arc(110.7,57.5) 111.03,57.5 111.17,57.36 arc(111.49,57.36) 111.49,57.68 111.35,57.83 arc(111.35,58.15) 111.67,58.15 111.82,58.01 arc(112.14,58.01) 112.14,58.33 112,58.47 arc(112,58.8) 112.32,58.8 112.46,58.65 arc(112.79,58.65) 112.79,58.98 112.64,59.12 arc(112.58,59.32) 112.71,59.49 117.17,63.95 117.17,82.08 116.26,83 116.26,87.22 120.43,91.39 120.43,93.8
M_ODT_A0: length 55.8
  TOP w0.089: 114.84,95.37 115.79,96.32 CPU.AW11
  TOP w0.165: 114.84,95.37 114.41,94.94 114.41,84.3 113.66,83.55 113.66,64.96 110.21,61.51 arc(110.16,61.37) 110.21,61.23 110.44,61 arc(110.44,60.71) 110.15,60.71 109.93,60.94 arc(109.64,60.94) 109.64,60.65 109.85,60.45 arc(109.85,60.16) 109.56,60.16 109.35,60.36 arc(109.06,60.36) 109.06,60.08 109.27,59.87 arc(109.27,59.59) 108.98,59.59 108.78,59.79 arc(108.49,59.79) 108.49,59.5 108.68,59.31 arc(108.68,59.02) 108.39,59.02 108.2,59.21 arc(107.91,59.21) 107.91,58.93 108.07,58.77 arc(108.07,58.49) 107.78,58.49 107.63,58.64 arc(107.48,58.7) 107.34,58.64 102,53.3 101,52.3 DIMM2.87
M_ODT_A1: length 58.7
  TOP w0.089: CPU.AU14 118.14,98.58 114.39,98.58 114.18,98.37
  TOP w0.165: 114.18,98.37 113.42,97.61 113.42,96.24 112.76,95.57 112.76,84.44 112.39,84.08 112.39,65.49 99.61,52.71 98.55,52.71 DIMM2.91
M_ODT_B0: length 74.4
  TOP w0.089: CPU.AM16 v4(119.9,103.22)
  GND w0.089: 118.29,94.22 118.29,94.96 118.96,95.63 118.96,97.36 119.64,98.19 119.64,100.01 119.47,100.18 119.47,102.78 v4(119.9,103.22)
  GND w0.14: DIMM1.87 100.75,42.12 100.75,44.92 101.18,45.34 101.18,46.7 102.04,47.55 102.04,48.98 101.19,49.83 101.19,50.49 102.02,51.32 102.02,52.06 102.4,52.44 102.82,52.44 114.25,63.86 114.25,68.12 114.48,68.35 114.91,68.35 arc(115.15,68.59) 114.91,68.84 114.61,68.84 arc(114.37,69.08) 114.61,69.33 114.91,69.33 arc(115.16,69.57) 114.91,69.82 114.6,69.82 arc(114.35,70.06) 114.6,70.31 114.95,70.31 115.16,70.52 115.16,81.27 114.28,82.17 114.28,88.13 118.29,92.14 118.29,94.22
M_ODT_B1: length 75.2
  TOP w0.089: CPU.AL16 v4(119.9,104.13)
  GND w0.089: v4(119.9,104.13) 118.07,102.3 118.07,99.23 117.24,98.41 117.24,96.63 117.12,96.51
  GND w0.14: DIMM1.91 98.53,42.79 98.53,45.49 99.12,46.08 99.12,46.83 99.97,47.68 99.97,48.36 99.12,49.21 99.12,50.61 99.98,51.48 99.98,52.14 100.76,52.91 100.96,52.91 111.77,63.72 111.77,66.38 arc(111.84,66.55) 112.01,66.62 112.46,66.62 arc(112.7,66.86) 112.46,67.11 112.01,67.11 arc(111.77,67.35) 112.01,67.6 112.46,67.6 arc(112.66,67.68) 112.74,67.88 112.74,71.13 113.31,71.7 113.31,80.26 112.74,80.83 112.74,88.73 116.03,92.02 116.03,95.42 117.12,96.51
M_PARITY_A: length 58.5
  TOP w0.089: 119.54,94.51 119.54,95.35 CPU.AY15
  TOP w0.216: 119.54,94.51 119.54,93.85 118.01,92.32 118.01,62.94 112.19,57.12 112.19,54.88 111.81,54.5 arc(111.67,54.45) 111.54,54.5 111.4,54.64 arc(111.13,54.64) 111.13,54.37 111.27,54.23 arc(111.27,53.96) 111,53.96 110.86,54.1 arc(110.59,54.1) 110.59,53.83 110.73,53.69 arc(110.73,53.42) 110.46,53.42 110.32,53.57 arc(110.05,53.57) 110.04,53.3 arc(110.05,53.3) 110.05,53.3 110.19,53.15 arc(110.19,52.88) 109.92,52.88 109.78,53.03 arc(109.51,53.03) 109.51,52.76 109.65,52.61 arc(109.65,52.35) 109.38,52.35 109.24,52.49 arc(108.97,52.49) 108.97,52.22 109.11,52.08 arc(109.17,51.94) 109.11,51.81 107.81,50.51 107.81,49.53 108.65,48.69 DIMM2.222
M_PARITY_B: length 77.6
  TOP w0.089: CPU.AL20 v4(123.56,104.13)
  GND w0.089: v4(123.56,104.13) 123.77,103.8 123.98,103.45 123.98,102.48 122.99,101.49 122.99,93.82 122.87,93.7 122.87,92.8
  GND w0.178: 122.87,92.8 122.87,90.6 119.46,87.19 119.46,60.15 118.49,59.18 arc(118.33,59.12) 118.18,59.18 arc(118.03,59.25) 117.88,59.18 117.86,59.16 arc(117.79,59.01) 117.86,58.86 arc(117.92,58.71) 117.86,58.55 117.84,58.54 arc(117.69,58.47) 117.53,58.54 arc(117.38,58.6) 117.23,58.54 117.21,58.52 arc(117.15,58.37) 117.21,58.21 arc(117.27,58.06) 117.21,57.91 117.19,57.89 arc(117.04,57.83) 116.89,57.89 arc(116.73,57.95) 116.58,57.89 116.56,57.87 arc(116.5,57.72) 116.56,57.57 arc(116.63,57.41) 116.56,57.26 116.55,57.24 arc(116.39,57.18) 116.24,57.24 arc(116.09,57.31) 115.94,57.24 109.34,50.65 109.34,49.88 109.34,49.88 109.34,46.7 arc(109.35,46.65) 109.38,46.59 109.38,46.01 arc(109.45,45.85) 109.61,45.78 109.8,45.78 arc(110.03,45.55) 109.8,45.33 109.61,45.33 arc(109.45,45.26) 109.38,45.1 109.38,40.02 108.65,39.29 DIMM1.222
MIC1_JD: length 42.2
  TOP w0.254: R116.2 28.12,179.22 40.44,179.22 41.49,180.27 41.49,183.1 42.46,184.07 42.46,186.12 42.84,186.51 42.84,187.88 44.55,189.6 44.55,192.39 43.41,193.53 43.41,197.82 46.32,200.73 48.43,200.73 49.59,201.89 AUDIO.13
MIC1_L: length 73
  TOP w0.254: R34.2 v2(19.72,195.33) ; L6.1 40.37,191.65 R45.1 39.22,193.05 41.89,195.71 41.89,198.61 42.58,199.31 42.58,203.1 40,205.68 32.47,205.68 30.14,203.35 30.14,202 29.56,201.43 27.21,201.43 26.91,201.72 26.91,203.15 27.17,203.41 Q5.C1 v2(27.65,204.11) ; R50.2 v2(28.93,191.97)
  BOTTOM w0.254: v2(28.93,191.97) 28.93,193.07 27.11,194.89 20.17,194.89 v2(19.72,195.33) 19.66,195.33 18.9,194.57 15.76,194.57 v3(15.39,194.94) 15.09,195.24 15.09,196.35 15.72,196.98 18.54,196.98 22.23,200.68 26.21,200.68 26.71,201.17 26.71,203.17 v2(27.65,204.11)
MIC1_L1: length 3.2
  TOP w0.254: CODEC.21 25.16,185.91 25.88,186.63
MIC1_L2: length 4.1
  TOP w0.254: R50.1 28.93,189.43 28.55,189.05 28.55,187.52 C68.1
MIC1_L_P: length 3.3
  TOP w0.254: Q5.B1 26.07,202.76 26.33,203.02 v3(26.33,204.22) 26.33,204.29 25.98,204.63 R9.2
MIC1_LL: length 19.8
  TOP w0.254: L6.2 41.98,191.81 C55.1 41.73,190.32 D4.2 42.33,189.3 43.54,190.51 43.54,191.97 42.39,193.11 42.39,198.24 46.99,202.84 AUDIO.14
MIC1_R: length 75.7
  TOP w0.254: v2(28.11,191.9) 27.79,191.59 R49.2 ; v2(25.38,201.36) 25.65,201.63 Q5.C2 26.22,202.11 26.4,201.94 26.4,201.51 27,200.92 29.77,200.92 30.65,201.79 30.65,203.14 32.61,205.11 39.85,205.11 42.08,202.89 42.08,199.52 41.36,198.81 41.36,196.08 38.38,193.09 38.38,186.74 38.2,186.57 38.2,185.52 R81.1 40.08,184.89 L12.1 ; v2(14.39,194) R40.2
  BOTTOM w0.254: v2(25.38,201.36) 22.2,201.36 18.33,197.49 15.47,197.49 14.39,196.41 v2(14.39,194) v3(19.99,194) 20.37,194.38 26.9,194.38 28.11,193.17 v2(28.11,191.9)
MIC1_R1: length 4.1
  TOP w0.254: 25.88,188.6 24.99,187.71 24.99,187.33 24.08,186.41 CODEC.22
MIC1_R2: length 1.6
  TOP w0.254: C60.1 27.79,188.73 R49.1
MIC1_R_P: length 3.5
  TOP w0.254: R10.2 29.03,204.6 v3(28.71,204.29) 28.71,203.24 28.23,202.76 Q5.B2
MIC1_RR: length 32.7
  TOP w0.254: AUDIO.11 55.71,204.22 49,204.22 48.36,203.59 48.36,202.13 47.73,201.49 46.36,201.49 42.9,198.03 42.9,193.32 44.04,192.18 44.04,189.81 41.73,187.49 D4.1 41.73,186.25 C73.1 41.66,185.08 L12.2
MIC1_VREFO-L: length 4.6
  TOP w0.254: R34.1 v3(19.72,192.28) 19.72,190.82 19.97,190.57 19.97,189.34 19.96,189.33 CODEC.28
MIC1_VREFO-R: length 5.5
  TOP w0.254: R40.1 14.48,192.06 v3(15.83,190.7) 16.03,190.51 17.37,190.51 17.96,189.92 CODEC.32
MIC2-VREFO: length 9.3
  TOP w0.254: D2.3 15.24,195.22 15.47,194.99 v3(15.47,193.62) 15.47,192.16 16.61,191.01 17.69,191.01 18.96,189.75 CODEC.30
MIC2-VREFO_L: length 1.3
  TOP w0.254: D2.2 13.44,197.22 R18.1
MIC2-VREFO_R: length 1.3
  TOP w0.254: R19.1 15.34,198.54 D2.1
MIC2_JD: length 23.6
  TOP w0.254: R38.1 v2(12.17,193.93)
  BOTTOM w0.254: v2(12.17,193.93) 11.79,194.32 10.39,194.32 9.88,193.81 4.55,193.81 3.21,192.47 3.21,185.24 4.1,184.35 6.83,184.35 F_AUDIO.6
MIC2_L: length 51.1
  TOP w0.254: F_AUDIO.1 4.55,188.28 4.04,188.79 4.04,190.92 D3.2 6.07,192.03 6.23,191.87 C42.2 R42.1 10.67,191.87 11.38,192.58 11.38,195.61 12.29,196.52 12.29,199.06 12.73,199.49 R18.2 v2(14.45,199.49) ; R44.2 31.09,195.01 29.94,196.17 29.94,197.21 27.78,199.36 23.53,199.36 21.52,201.36 19.34,201.36 19.03,201.68 19.03,203.14 19.29,203.41 Q3.C1 v2(19.77,204.11)
  BOTTOM w0.254: v2(19.77,204.11) 19.77,201.65 17.98,199.85 14.82,199.85 v2(14.45,199.49)
MIC2_L1: length 3.2
  TOP w0.254: CODEC.16 24.59,183.41 25.31,182.7 25.88,182.7
MIC2_L2: length 10.5
  TOP w0.254: R44.1 31.09,189.77 29.57,188.24 29.57,183.65 28.61,182.7 C85.2
MIC2_L_P: length 3.7
  TOP w0.254: Q3.B1 18.33,202.76 18.52,202.95 18.52,203.52 18.64,203.65 v3(18.64,204.29) 18.64,204.38 R5.2
MIC2_R: length 48.6
  TOP w0.254: R43.2 30.01,195.33 29.43,195.91 29.43,197 27.57,198.86 23.31,198.86 21.31,200.86 19.09,200.86 18.52,201.43 18.52,201.87 18.28,202.11 Q3.C2 v2(17.77,201.38) ; R19.2 v2(15.34,200.54) 13.06,200.54 11.72,199.21 11.72,196.67 10.83,195.78 10.83,194.7 10.23,194.09 R29.1 C30.2 5.31,194.09 D3.1 3.53,192.32 3.53,187.65 F_AUDIO.3
  BOTTOM w0.254: v2(17.77,201.38) 17.77,201.05 17.26,200.54 v2(15.34,200.54)
MIC2_R1: length 3.2
  TOP w0.254: CODEC.17 23.98,183.91 v3(24.56,184.5) 24.73,184.66 25.88,184.66
MIC2_R2: length 7.8
  TOP w0.254: C76.2 28.23,184.66 29.06,185.49 29.06,188.45 30.01,189.41 R43.1
MIC2_R_P: length 3.3
  TOP w0.254: Q3.B2 20.36,202.76 20.6,203.01 v3(20.6,204.35) 20.6,205.26 R6.2
MONO_L: length 56
  TOP w0.254: v2(9.5,186.7) C67.1 ; v2(10.26,200.22) 10.1,200.38 R12.1 10.1,203.11 10.41,203.41 Q1.C1
  BOTTOM w0.254: v2(9.5,186.7) 9.12,186.31 9.12,177.44 5.44,173.76 INT_SPK.1 3.79,173.42 2.2,175.01 2.2,198.38 3.34,199.52 9.56,199.52 v2(10.26,200.22)
MONO_L_C: length 2.6
  TOP w0.254: C67.2 12.26,186.41 CODEC.39
MONO_L_P: length 3.3
  TOP w0.254: R1.2 9.28,204.57 v3(9.5,204.35) 9.6,204.25 9.6,203.05 9.31,202.76 Q1.B1
MONO_R: length 56.3
  TOP w0.254: Q1.C2 8.88,201.19 R11.1 8.96,200.32 v2(8.87,200.22) ; v2(10.45,184.41) 10.45,184.35 10.58,184.22 C82.1
  BOTTOM w0.254: v2(10.45,184.41) 10.33,184.41 9.69,183.77 9.69,177.3 6.77,174.38 6.77,172.22 INT_SPK.3 4.67,170.88 1.56,174 1.56,198.51 3.28,200.22 v2(8.87,200.22)
MONO_R_C: length 3.8
  TOP w0.254: C82.2 12.6,183.46 13.12,183.98 13.12,184.92 13.62,185.41 CODEC.41
MONO_R_P: length 3.5
  TOP w0.254: Q1.B2 11.41,202.76 11.85,203.21 v3(11.85,204.29) 12.33,204.76 R2.2
MS_CLK: length 217.7
  TOP w0.102: L5.1 175.62,199.4 173.01,199.4 172.69,199.72 RN1.2 172.25,200.16 171.98,199.89 171.98,198.65 174.98,195.65 178.41,195.65 184.38,189.68 188.84,189.68 199.16,179.36 199.16,93.27 v2(198.41,92.53) ; U35.80 v2(184.2,23.3)
  BOTTOM w0.102: v2(198.41,92.53) 198.68,92.26 198.68,57.36 188.44,47.12 188.44,42.61 193.93,37.13 193.93,30.76 v3(193.21,30.04) 192.48,29.31 192.48,21.82 191.17,20.52 189.01,20.52 186.23,23.3 v2(184.2,23.3)
MS_DATA: length 216.4
  TOP w0.102: v2(183.43,23.25) 183.86,22.82 184.4,22.82 184.48,22.9 U35.79 ; L4.1 175.49,199.71 173.51,199.71 173.33,199.9 173.33,200.47 173.07,200.73 RN1.4 172.13,200.73 171.76,200.36 171.76,198.55 174.89,195.42 178.32,195.42 184.28,189.45 188.75,189.45 198.93,179.27 198.93,93.93 v2(198.35,93.35)
  BOTTOM w0.102: v2(183.43,23.25) 183.86,22.82 186.39,22.82 188.92,20.29 191.27,20.29 192.76,21.78 192.76,27.38 v3(193.33,27.95) 194.16,28.77 194.16,37.36 198.91,42.11 198.91,92.79 v2(198.35,93.35)
MSCLK: length 12.4
  TOP w0.102: L5.2 C13.2 178.76,198.73 179.24,198.25 183.05,198.25 184.82,196.47 184.82,194.31 PSKM.11
MSDATA: length 12.8
  TOP w0.102: PSKM.7 184.1,199.65 179.11,199.65 178.76,200 C7.2 L4.2
MXDIN_0: length 33
  TOP w0.102: v2(62.22,171.73) 62.51,171.44 62.51,168.85 60.62,166.97 60.62,166.16 U19.2 ; v2(65.91,171.79) 65.63,172.06 65.63,172.34 69.35,176.05 69.35,180.05 68.81,180.58 68.81,181.29 68.89,181.36 U11.3 68.81,181.44 68.81,186.91 68.69,187.04 68.69,189.29 68.15,189.82 68.15,190.18 USB2_LAN.P3
  BOTTOM w0.102: v2(62.22,171.73) 62.5,172.01 62.5,172.57 62.97,173.04 65.19,173.04 65.63,172.6 65.63,172.06 v2(65.91,171.79)
MXDIN_1: length 37.6
  TOP w0.102: USB2_LAN.P5 70.66,190.15 70.66,189.8 71.25,189.21 71.25,180.31 70.65,179.71 70.65,179 U11.6 70.65,178.73 70.65,175.58 69.23,174.15 69.23,172.99 v2(69.55,172.66) ; U19.5 59.43,166.17 59.43,169.61 60.38,170.55 60.38,171.46 v2(60.1,171.73)
  BOTTOM w0.102: v2(69.55,172.66) 69.28,172.93 69.28,173.78 68.75,174.31 61.85,174.31 60.38,172.83 60.38,172.01 v2(60.1,171.73)
MXDIN_2: length 42.8
  TOP w0.102: U19.7 58.6,166.67 58.62,166.69 58.62,170.35 58.26,170.71 58.26,171.43 v2(57.98,171.71) ; v2(72.55,173.42) 72.28,173.69 72.28,176.19 73.6,177.51 73.6,179.73 73.07,180.26 73.07,181.3 73.14,181.36 U12.3 73.07,181.46 73.07,185.9 73.65,186.48 73.65,189.39 73.2,189.84 73.2,190.15 USB2_LAN.P7
  BOTTOM w0.102: v2(72.55,173.42) 72.29,173.68 72.29,174.33 71.04,175.58 60.43,175.58 58.27,173.42 58.27,172 v2(57.98,171.71)
MXDIN_3: length 48
  TOP w0.102: USB2_LAN.P9 76.1,189.49 76.27,189.33 76.27,187.23 75.19,186.15 75.19,183.86 75.5,183.54 75.5,180.24 74.98,179.72 74.98,178.94 U12.6 74.97,178.78 74.97,177.06 74.21,176.3 74.21,175.07 v2(74.49,174.79) ; v2(55.84,171.65) 56.12,171.37 56.12,170.59 55.73,170.19 55.73,166.34 56.83,165.25 57.1,165.25 57.13,165.22 U19.10
  BOTTOM w0.102: v2(55.84,171.65) 56.12,171.93 56.12,173.5 59.47,176.85 73.07,176.85 74.21,175.71 74.21,175.07 v2(74.49,174.79)
MXDIP_0: length 33
  TOP w0.102: USB2_LAN.P2 66.99,188.19 66.99,189.13 67.4,189.54 67.93,189.54 68.33,189.14 68.33,186.89 68.46,186.76 68.46,180.43 68.99,179.9 68.99,178.96 U11.4 68.89,178.85 68.99,178.76 68.99,176.2 65.28,172.48 65.28,172.07 v2(64.99,171.79) ; U19.1 60.98,166.16 60.98,166.82 62.87,168.71 62.87,171.47 v2(63.13,171.73)
  BOTTOM w0.102: v2(63.13,171.73) 62.85,172.01 62.85,172.43 63.11,172.69 65.04,172.69 65.28,172.45 65.28,172.07 v2(64.99,171.79)
MXDIP_1: length 37.7
  TOP w0.102: USB2_LAN.P4 69.48,188.25 69.48,189.16 69.87,189.55 70.41,189.55 70.9,189.07 70.9,181.47 U11.1 70.93,181.22 70.93,180.49 70.3,179.86 70.3,175.73 68.87,174.3 68.87,172.9 v2(68.64,172.66) ; v2(61.01,171.73) 60.73,171.46 60.73,170.41 59.78,169.46 59.78,166.16 U19.4
  BOTTOM w0.102: v2(68.64,172.66) 68.92,172.95 68.92,173.63 68.6,173.96 62,173.96 60.73,172.69 60.73,172.01 v2(61.01,171.73)
MXDIP_2: length 42.8
  TOP w0.102: U19.6 59,166.67 58.98,166.69 58.98,170.5 58.62,170.86 58.62,171.43 v2(58.9,171.71) ; USB2_LAN.P6 72.08,188.18 72.08,189.16 72.47,189.56 72.98,189.56 73.29,189.24 73.29,186.63 72.71,186.05 72.71,180.11 73.25,179.58 73.25,178.95 U12.4 73.25,178.78 73.25,177.66 71.92,176.34 71.92,173.71 v2(71.63,173.42)
  BOTTOM w0.102: v2(58.9,171.71) 58.62,171.98 58.62,173.28 60.57,175.23 70.89,175.23 71.93,174.19 71.93,173.72 v2(71.63,173.42)
MXDIP_3: length 48
  TOP w0.102: v2(73.58,174.79) 73.86,175.07 73.86,176.45 74.62,177.21 74.62,178.78 74.63,178.79 74.63,179.87 75.15,180.39 75.15,181.28 U12.1 75.15,181.45 75.15,183.39 74.83,183.71 74.83,186.29 75.91,187.37 75.91,189.18 75.46,189.63 74.83,189.63 74.55,189.35 74.55,188.25 USB2_LAN.P8 ; U19.9 57.14,165.62 57.13,165.6 56.97,165.6 56.08,166.49 56.08,170.05 56.48,170.44 56.48,171.37 v2(56.76,171.65)
  BOTTOM w0.102: v2(56.76,171.65) 56.48,171.93 56.48,173.35 59.62,176.5 72.92,176.5 73.86,175.57 73.86,175.07 v2(73.58,174.79)
NAFD_L: length 12.2
  TOP w0.102: LPT.14 149.87,8.93 149.87,10.2 150.34,10.67 CN1.2 150.58,11.58 150.25,11.91 150.25,13.57 150.79,14.11 RN18.7 150.98,14.55 151.55,15.12 RN15.6
NPINIT_L: length 11.7
  TOP w0.102: RN16.8 RN19.7 154.98,14.11 154.45,13.57 154.45,12.22 154.71,11.95 CN2.2 154.41,10.67 154,10.27 154,7.73 152.12,5.85 LPT.16
NPRD0: length 15.9
  TOP w0.102: LPT.2 148.21,4.43 148.21,6.83 150.1,8.72 150.1,9.67 150.21,9.77 151.03,9.77 151.4,10.14 CN1.4 151.4,11.14 150.48,12.06 150.48,13.23 150.74,13.5 151.39,13.5 151.55,13.66 RN18.5 151.55,14.61 152.05,15.11 RN15.4
NPRD1: length 21.1
  TOP w0.102: LPT.3 150.47,4.7 148.88,4.7 148.44,5.15 148.44,6.29 149.45,7.31 152.82,7.31 153.54,8.03 153.54,9.63 153.4,9.77 152.71,9.77 152.21,10.27 CN1.6 152.21,11.14 153.07,12.01 153.07,13.34 152.93,13.48 152.23,13.48 152.05,13.66 RN18.3 152.05,14.54 152.63,15.12 RN15.2
NPRD2: length 15.2
  TOP w0.102: LPT.4 153.39,4.32 153.39,6.67 154.23,7.51 154.23,9.67 154.33,9.77 155.22,9.77 155.52,10.08 CN2.4 155.52,11.46 154.67,12.31 154.67,13.23 154.89,13.45 155.54,13.45 155.74,13.66 RN19.5 RN16.6
NPRD3: length 13.7
  TOP w0.102: RN16.2 RN19.1 157.01,14.11 157.56,13.56 157.56,11.98 157.15,11.58 CN2.8 157.46,10.67 157.9,10.23 157.9,4.26 LPT.5
NPRD4: length 13.9
  TOP w0.102: RN17.8 RN20.7 158.79,14.11 158.45,13.76 158.45,12.15 158.84,11.76 CN3.2 158.6,10.67 158.13,10.2 158.13,4.67 LPT.6
NPRD5: length 16.5
  TOP w0.102: RN17.6 RN20.5 159.75,13.73 159.52,13.5 158.94,13.5 158.67,13.23 158.67,12.25 159.65,11.27 CN3.4 159.65,10.14 159.28,9.77 158.46,9.77 158.36,9.67 158.36,8.06 159.04,7.37 160,7.37 160.76,6.61 160.76,4.58 LPT.7
NPRD6: length 15.5
  TOP w0.102: RN17.4 RN20.3 160.25,13.75 160.5,13.5 161.05,13.5 161.25,13.3 161.25,11.87 160.47,11.08 CN3.6 160.47,10.22 160.76,9.92 161.54,9.92 161.8,9.67 161.8,7.65 163.3,6.15 163.3,4.58 LPT.8
NPRD7: length 16.7
  TOP w0.102: LPT.9 165.9,4.51 165.9,6.23 165.19,6.94 162.83,6.94 162.03,7.74 162.03,10.17 161.52,10.67 CN3.8 161.28,11.51 161.48,11.71 161.48,13.63 161.01,14.11 RN20.1 RN17.2
NSLIN_L: length 13.9
  TOP w0.102: RN16.4 RN19.3 156.24,13.66 156.44,13.47 157.08,13.47 157.1,13.44 157.11,13.44 157.33,13.22 157.33,12.2 156.34,11.21 CN2.6 156.34,10.27 156.68,9.92 157.38,9.92 157.67,9.63 157.67,8.03 155.49,5.85 LPT.17
NSTB_L: length 16.3
  TOP w0.102: RN15.8 150.02,15.56 149.45,14.99 R567.1 150.03,13.12 150.03,11.59 C573.2 148.91,10.48 148.91,8.41 147.55,7.05 146.66,7.05 145.92,6.32 145.92,4.17 LPT.1
OPC_ZVM_L: length 56.4
  TOP w0.089: 144.73,115.87 140.95,112.08 140.95,111.45 140.49,110.99 CPU.AC38
  TOP w0.102: R353.2 181.08,91.26 180.07,92.26 180.07,95.43 178.54,96.97 v1(176.76,96.97) 175.34,96.97 169.67,102.64 169.67,104.05 157.51,116.21 145.07,116.21 144.73,115.87
PC_BEEP: length 2.6
  TOP w0.102: TP3.1 22.45,178.82 21.53,179.74 CODEC.12
PCH_GPIO24_DIS_ME: length 4.1
  TOP w0.102: RJ3.3 27.6,65.61 v2(27.99,65.22) 28.75,64.46 Q36.E
  BOTTOM w0.102: v2(27.99,65.22) 28.02,65.19 v3(28.02,64.36)
PCH_GPIO24_DIS_ME_B: length 4.7
  TOP w0.102: Q36.B v2(28.52,62.43) 26.3,62.43 R432.1
  BOTTOM w0.102: v3(29.39,62.45) 28.55,62.45 v2(28.52,62.43)
PCH_GPIO24_DIS_ME_C: length 1.6
  TOP w0.102: R431.1 26.55,63.44 Q36.C
PCH_GPP_F22: length 151.3
  TOP w0.089: PCH1.W39 51.03,80.52 51.26,80.3 51.26,79.22 51.19,79.15 51.19,78.63 51.73,78.09 51.73,77.36 51.36,76.99 51.36,75.18
  TOP w0.102: v2(41.55,62.07) 41.2,62.43 30.79,62.43 30.1,61.74 28.17,61.74 27.71,62.2 26.75,62.2 26.09,61.54 25.62,61.54 25.04,62.12 24.87,62.29 24.87,62.65 24.08,63.44 21.16,63.44 20.73,63.01 15.71,63.01 11.41,67.32 v2(11.41,67.99) ; D14.2 10.31,148.48 v2(10.77,148.02) ; 51.36,75.18 51.36,70.26 R413.1 51.23,69.27 51.23,65.93 v2(51.64,65.52)
  BOTTOM w0.102: v2(51.64,65.52) 50.98,64.86 v3(50.19,64.86) 49.38,64.86 47.42,62.91 43.23,62.91 42.39,62.07 v2(41.55,62.07) ; v2(11.41,67.99) 11.75,67.99 12.42,68.66 12.42,69.58 13.18,70.34 13.18,71.24 12.43,71.99 12.43,72.88 12.62,73.07 12.62,75.26 11.06,76.83 11.06,77.94 10.58,78.43 10.03,78.98 8.91,78.98 7,80.89 7,85.45 6.26,86.19 6.26,95.62 6.96,96.32 6.96,102.32 7.47,102.82 7.47,131.02 6.93,131.56 6.93,136.5 7.95,137.52 7.95,145.46 10.52,148.02 v2(10.77,148.02)
PCH_INTRUDER_L: length 10.4
  TOP w0.089: R360.2 33.31,89.38 33.31,93.5 34.81,95.01 37.91,95.01 PCH1.BE11
PCH_JTAG_TCK: length 13
  TOP w0.089: 43.83,105.69 43.83,105.15 43.73,105.05 43.73,100.48 43.44,100.19 43.44,99.63 43.75,99.32 PCH1.AN3
  TOP w0.102: R308.1 45.01,110.28 TP4.1 45.01,108.86 43.83,107.68 43.83,105.69
PCH_JTAG_TDI: length 84
  TOP w0.089: PCH1.AP2 43.19,99.62 42.96,99.85 42.96,100.28 43.32,100.63 43.32,105.38 43.37,105.43 43.37,105.69
  TOP w0.102: v2(55.28,120.78) 54.01,120.78 53.35,120.12 50.56,120.12 46.18,115.74 46.18,114.6 44.23,112.65 44.23,111.43 R307.2 44.22,110.56 44.22,108.76 43.37,107.9 43.37,105.69 ; R214.2 79.06,159.52 76.77,157.23 v2(75.92,157.23)
  BOTTOM w0.102: v2(75.92,157.23) 74.11,157.23 71.83,154.96 67.96,154.96 54.52,141.52 54.52,135.58 v3(54.86,135.24) 56.24,133.86 56.24,121.74 v2(55.28,120.78)
PCH_JTAG_TDO: length 91.5
  TOP w0.089: 43.6,105.69 43.6,105.28 43.52,105.2 43.52,100.56 43.19,100.22 PCH1.AP1
  TOP w0.102: v2(86.08,163.65) 86.53,163.2 R204.2 ; 43.6,105.69 43.6,107.78 44.45,108.63 44.45,110.14 45.11,110.8 45.11,112.25 46.22,113.36 R300.2 47.27,113.89 47.27,116.26 50.9,119.89 53.89,119.89 v2(54.27,120.27)
  BOTTOM w0.102: v2(54.27,120.27) 53.82,120.72 53.82,129.93 v3(53.19,130.56) 53.19,141.23 67.65,155.69 71.5,155.69 75.13,159.33 78.59,159.33 82.24,162.98 85.41,162.98 v2(86.08,163.65)
PCH_JTAG_TMS: length 93
  TOP w0.089: 42.91,105.69 42.91,100.81 42.57,100.47 PCH1.AR2
  TOP w0.102: 42.91,105.69 42.91,108.16 43.76,109.01 43.76,112.95 45.19,114.37 R295.2 45.72,115.37 45.72,116.21 50.09,120.58 52.98,120.58 54.39,121.99 v2(54.9,121.99) ; R205.2 87.61,162.88 v2(86.84,163.65)
  BOTTOM w0.102: v2(54.9,121.99) v3(54.9,123.26) 54.9,129.99 53.57,131.32 53.57,141.28 67.76,155.47 71.63,155.47 75.11,158.95 78.53,158.95 82.25,162.66 85.86,162.66 v2(86.84,163.65)
PCH_JTAGX: length 89
  TOP w0.089: PCH1.AR3 42.57,99.19 42.79,99.41 42.79,99.75 42.77,99.77 42.77,100.38 43.12,100.72 43.12,105.66 43.14,105.69
  TOP w0.102: 43.14,105.69 43.14,108.03 43.99,108.88 43.99,112.85 45.95,114.8 45.95,115.96 50.34,120.35 53.14,120.35 54.08,121.29 v2(54.39,121.29) ; v2(76.49,157.8) 77.02,157.8 79.82,160.6 R209.2 R201.2
  BOTTOM w0.102: v2(76.49,157.8) 74.32,157.8 71.73,155.21 67.83,155.21 54.01,141.39 54.01,133.94 v3(54.92,133.04) 55.92,132.03 55.92,122.24 54.97,121.29 v2(54.39,121.29)
PCH_PECI: length 74.4
  TOP w0.089: PCH1.AL3 44.84,99.19 45.08,99.42 45.08,99.72 45.01,99.79 45.01,104.53 45.66,105.18 45.66,105.69
  TOP w0.102: v2(57.46,118.69) 57.46,117.95 55.8,116.3 52.25,116.3 R296.1 50.14,114.19 50.14,111.41 C310.1 50.03,110.33 49.3,110.33 45.66,106.68 45.66,105.69 ; R233.2 74.75,155.2 73.89,155.2 70.81,152.12 69.08,152.12 v2(68.58,151.62)
  BOTTOM w0.102: v2(57.46,118.69) 57.46,118.84 v3(58.19,119.58) 58.95,120.34 58.95,143.33 65.33,149.7 66.3,149.7 68.22,151.62 v2(68.58,151.62)
PCH_PLTRST_L: length 420.4
  TOP w0.102: v4(30,78.38) 29.35,77.73 R376.2 ; v2(10.96,70.3) 10.92,70.26 10.92,67.47 11.34,67.06 11.97,66.42 15.74,62.65 20.7,62.65 21.23,63.19 24,63.19 24.59,62.6 24.59,62.25 25.55,61.28 26.54,61.28 v2(26.67,61.41) ; v2(12.74,158.44) 13.02,158.72 14.73,158.72 15.73,159.72 19.1,159.72 20.23,160.84 21.25,160.84 21.87,161.46 26.57,161.46 v2(26.82,161.71) ; v2(41.43,171.98) 42.83,171.98 44.82,169.98 47.48,169.98 51.41,166.06 51.41,158.14 53.62,155.92 55.21,155.92 R223.2 ; R574.1 172.85,10.64 172.31,11.18 171.43,11.18 v2(170.47,12.13)
  BOTTOM w0.102: v2(12.74,158.44) 13.01,158.17 13.01,153.52 4.14,144.65 4.14,80.84 7.79,77.19 7.79,75.3 11.05,72.04 11.05,70.39 v2(10.96,70.3) ; v2(26.82,161.71) 26.57,161.97 26.57,168.22 30.84,172.48 40.92,172.48 v2(41.43,171.98) ; v2(170.47,12.13) v3(169.27,12.13) 168.13,12.13 167.13,11.13 149.17,11.13 148.71,11.59 148.71,13.86 145.08,17.49 136.91,17.49 132.48,13.06 119.56,13.06 117.59,15.03 94.46,15.03 93.14,16.35 68.27,16.35 63.39,21.23 56.45,21.23 54.75,19.53 41.65,19.53 40.34,18.21 33.92,18.21 31.59,15.88 18.9,15.88 14.96,19.82 14.96,34.43 18.38,37.85 18.38,49.78 23.09,54.49 23.09,55.49 23.46,55.86 24.14,55.86 24.8,56.52 24.8,57.89 26.67,59.76 v2(26.67,61.41) 26.67,63.14 27.18,63.65 27.18,65.89 28.02,66.73 28.02,71.71 28.94,72.64 28.94,73.25 29.85,74.15 29.85,78.22 v4(30,78.38)
PCH_PWROK: length 171
  TOP w0.089: v4(40.47,95.76) 40.62,95.61 PCH1.AW11
  TOP w0.102: v7(5.31,109.35) 5.18,109.48 R316.2 ; Q37.G 46.71,60.71 v2(46.33,60.33) ; v2(10.82,73.92) 10.82,74.35 11.96,75.48 13.38,75.48 14.55,76.65 18.31,76.65 v2(18.69,77.03) 18.69,77.92 22.17,81.39 23.73,81.39 R369.1 24,82.63 24,85.03 C355.1 24.49,86.56 v2(23.6,87.45) ; v2(16.14,57.68) 16.46,57.99 19.78,57.99 20.37,57.4 20.37,56.71 24.54,52.54 24.54,50.37 25.63,49.28 27.28,49.28 v2(28.49,48.08) 28.33,47.92 28.33,41.46 29.34,40.46 29.34,37.46 28.55,36.67 R467.2
  BOTTOM w0.089: v4(40.47,95.76) 40.39,95.76 39.98,95.35 36.01,95.35 31.26,100.11
  BOTTOM w0.102: v2(18.69,77.03) 19.15,76.57 19.15,69.72 18.31,68.89 18.31,61.48 16.14,59.31 v2(16.14,57.68) ; v2(23.6,87.45) 23.6,97.7 27.08,101.19 30.18,101.19 31.26,100.11 ; v7(5.31,109.35) 5.05,109.1 5.05,101.29 5.82,100.53 5.82,97.2 5.07,96.45 5.07,85.59 5.82,84.84 5.82,80.46 8.7,77.57 8.7,76.04 v2(10.82,73.92) ; v2(46.33,60.33) 44.29,60.33 v3(42.01,58.06) 38.23,54.27 35,54.27 28.8,48.08 v2(28.49,48.08)
PCH_PWROK_R: length 2.7
  TOP w0.102: Q45.G 28.04,34.31 28.55,34.82 R467.1 R466.1
PCH_RI_L: length 361.1
  TOP w0.089: PCH1.AV13 41.55,94.29 v4(41.14,94.69)
  TOP w0.102: R415.1 21.28,70.17 18.9,70.17 v2(18.39,70.68) ; Q48.C 161.27,32.84 160.98,33.12 C457.1 162.06,34.55 181.71,34.55 v2(182.86,33.41)
  BOTTOM w0.089: 31.26,99.42 35.75,94.93 40.12,94.93 40.31,95.11 40.72,95.11 v4(41.14,94.69)
  BOTTOM w0.102: v2(182.86,33.41) 182.86,32.78 v3(182.32,32.25) 181.78,31.7 181.78,21.28 180.25,19.75 178.08,19.75 176.4,18.08 176.4,15.47 176.8,15.08 176.8,10.47 174.1,7.78 167.65,7.78 167.07,8.36 150.52,8.36 150.09,7.93 146.66,7.93 145.52,6.79 144.54,6.79 142.3,9.02 138.16,9.02 137.46,9.72 136.77,10.41 135.41,10.41 134.69,9.68 129.67,9.68 128.93,8.95 119.68,8.95 119.2,9.43 116.65,9.43 115.67,10.41 107.54,10.41 106.79,9.66 98.27,9.66 96.54,7.93 69.13,7.93 67.11,9.95 67.11,10.41 66.65,10.86 60.94,10.86 60.3,11.5 60.3,13.15 59.54,13.91 57.89,13.91 55.58,16.22 43.27,16.22 41.93,14.88 35.45,14.88 30.83,10.27 29.74,9.17 27.5,9.17 26.54,10.14 22.38,10.14 20.46,8.22 18.61,8.22 18.13,8.7 17.43,9.4 13.25,9.4 11.69,10.97 10.29,10.97 9.44,10.11 6.89,10.11 5.47,11.54 5.31,11.7 5.31,30.29 6.06,31.04 8.01,31.04 9.28,32.32 9.28,33.77 12.66,37.15 12.66,44.94 11.84,45.76 11.84,46.96 12.17,47.29 12.17,50.74 15.28,53.86 15.28,58.87 18.09,61.67 18.09,68.98 18.39,69.29 v2(18.39,70.68) 18.14,70.94 18.14,77.16 22.23,81.25 22.23,84.85 24.46,87.09 24.46,97.92 27.22,100.68 30,100.68 30.14,100.54 30.85,99.82 31.26,99.42
PCH_RI_L_0: length 7.7
  TOP w0.102: R531.2 R524.2 160.48,24.01 160.48,28.21 v1(160.27,28.42) 160.25,28.44 Q48.B
PCH_SPI_CLK: length 14.9
  TOP w0.089: R383.2 33.08,74.81 34.07,75.8 34.07,78.15 36.09,80.17 36.09,83.13 v4(36.47,83.51) 36.83,83.86 36.83,84.3 37.96,85.43 38.22,85.43 38.25,85.46 38.55,85.46 38.77,85.24 PCH1.BC31
  BOTTOM w0.089: v4(36.47,83.51) v3(36.47,82.67)
PCH_SPI_CS1: length 2.2
  TOP w0.089: v4(40.96,85.67) 40.71,85.41 PCH1.AW31
  BOTTOM w0.089: v4(40.96,85.67) 40.96,84.43 STP16.1
PCH_SPI_CS2: length 1.5
  TOP w0.089: v4(42.67,84.69) 42.25,85.11 PCH1.AT31
  BOTTOM w0.089: v4(42.67,84.69) 42.69,84.71 STP15.1
PCH_SPKR: length 305.5
  TOP w0.089: PCH1.BD26 36.9,87.51 36.02,86.63 36.02,85.46 35.08,84.52 35.08,81.93 34.34,81.2 34.34,80.64 32.64,78.94 32.02,78.94
  TOP w0.102: 32.02,78.94 29.9,78.94 28.8,77.84 28.8,74.3 v2(29.06,74.05) ; R452.1 192.92,52.9 190.91,52.9 185.46,47.45 v2(185.46,43.44)
  BOTTOM w0.102: v2(185.46,43.44) 185.46,41.66 186.77,40.35 186.77,38.46 180.98,32.67 180.98,23.02 179.79,21.84 178,21.84 v3(177.42,21.25) 176.81,21.25 175.49,19.93 175.49,16.96 174.85,16.33 173.97,16.33 171.93,14.29 171.93,11.94 171.23,11.25 167.68,11.25 167.34,10.9 148.95,10.9 147.12,12.73 139.33,12.73 138.72,13.34 138.72,14.36 138.21,14.86 136.69,14.86 135.99,14.17 134.75,14.17 133,12.41 119.09,12.41 117.26,14.24 94.76,14.24 94.22,13.7 92.58,13.7 91.1,15.18 87.61,15.18 86.67,16.12 68.18,16.12 63.3,21 56.54,21 54.84,19.3 41.86,19.3 40.55,17.98 34.02,17.98 31.69,15.65 18.8,15.65 14.73,19.72 14.73,34.53 18.15,37.94 18.15,49.97 22.84,54.65 22.84,55.56 23.37,56.09 23.99,56.09 24.42,56.52 24.42,58.1 26.19,59.86 26.19,65.23 27.79,66.83 27.79,72.46 STP28.1 28.3,73.28 v2(29.06,74.05)
PCH_SYSPWROK: length 480.6
  TOP w0.089: v4(38.2,101.39) 39.12,101.39 40.32,100.18 PCH1.AY1
  TOP w0.102: R544.1 C538.1 168.06,19.25 168.81,18.5 U35.29 170.93,18.5 171.7,19.27 172.09,19.27 173.39,20.58 177.2,20.58 179.87,17.91 v2(181.84,17.91) ; v2(5.56,107.38) 6.77,107.38 8.74,109.35 10.5,109.35 10.69,109.16 10.69,107.59 12.6,105.68 v2(12.6,105.63) ; Q33.D v2(189.33,92.65) ; Q26.C v2(6.07,125.67)
  BOTTOM w0.089: v4(38.2,101.39) 37.74,101.85 33.45,101.85 31.66,103.64
  BOTTOM w0.102: v2(12.6,105.63) 13.7,104.53 14.71,104.53 15.72,103.51 19.16,103.51 20.22,104.56 21.21,104.56 21.49,104.29 31.01,104.29 31.66,103.64 ; v2(6.07,125.67) 6.4,125.34 6.4,108.22 v2(5.56,107.38) 5.31,107.13 5.31,101.4 6.05,100.67 6.05,97.07 5.32,96.35 5.32,85.73 6.08,84.97 6.08,80.51 8.93,77.67 8.93,76.54 11.54,73.93 11.59,73.93 11.86,73.66 11.86,73.27 11.74,73.15 11.74,70.94 11.94,70.73 11.94,69.54 12.19,69.28 12.19,68.88 11.86,68.55 11.23,68.55 10.91,68.23 10.91,62.45 5.66,57.19 5.66,51.47 2.51,48.33 2.51,4.2 4.45,2.26 60.37,2.26 61.79,3.68 64.2,3.68 65.61,2.26 96.17,2.26 98.09,4.17 116.78,4.17 117.03,4.43 118.76,4.43 118.99,4.2 179.26,4.2 185.19,10.13 185.19,12.78 181.84,16.13 v2(181.84,17.91) 182.66,18.74 187.24,18.74 187.62,19.12 187.62,20.07 186.54,21.15 183.05,21.15 182.09,22.1 182.09,30.42 187.24,35.57 187.24,40.96 186.73,41.47 186.73,47.81 192.89,53.97 192.89,63.44 v3(190.09,66.24) 189.97,66.36 189.97,92.02 v2(189.33,92.65)
PCH_THERMTRIP_L: length 15.6
  TOP w0.089: 47.1,105.69 47.1,105.24 45.89,104.02 45.89,99.43 46.02,99.3 PCH1.AJ3
  TOP w0.102: R313.2 52.49,109.89 v1(52.32,109.72) 51.54,108.93 49.71,108.93 47.1,106.33 47.1,105.69
PCH_TRIGIN: length 17.3
  TOP w0.089: PCH1.AK1 45.46,104.35 46.47,105.36 46.47,105.69
  TOP w0.102: 46.47,105.69 46.47,106.53 49.45,109.52 50.68,109.52 51.64,110.47 51.64,112.59 v1(51.84,112.79) 52.49,113.44 R298.1
PCH_TRIGIN_R: length 107.6
  TOP w0.102: R298.2 53.13,115.3 56.35,115.3 v2(57.85,116.79) ; CPU.B3 106.15,131.11 105.61,131.64 104.05,131.64 102.9,132.79 102.9,136 97.66,141.24 90.54,141.24 88.49,139.2 88.49,136.68 87.9,136.09 86.04,136.09 85.88,136.25 85.55,136.57 85.03,137.1 85.03,143.27 79.92,148.38 78.73,149.57 78.73,152.8 v2(79.22,153.29)
  BOTTOM w0.102: v2(57.85,116.79) 58.41,116.79 60.2,118.58 60.2,142.79 65.84,148.43 68.26,148.43 72.83,153 v3(76.63,153) 76.99,152.65 78.58,152.65 v2(79.22,153.29)
