# Allegro board ECS H11H4-AI-V1.0-OK.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VR_CSP3_IC: length 10.1
  TOP w0.203: C81.1 163.07,183.31 163.3,183.08 165.01,183.08 165.72,182.37 U10.43 ; C81.1 161.99,183.71 R92.2 160.28,183.74 159.46,184.57 R85.1 ; C81.1 R84.1
VR_CSP3_R: length 1.1
  TOP w0.203: R77.2 R78.1
VR_CSREF: length 15.1
  TOP w0.203: U10.44 164.44,181.97 164.28,181.81 163.58,181.81 C86.2
  TOP w0.254: R64.1 161.04,188.86 v2(162.09,188.86) 162.34,188.86 162.92,189.43 R59.1 ; C86.2 162.44,182.95 v2(162.41,182.95) ; R76.1 162.09,185.87 v2(162.22,186)
  BOTTOM w0.254: v2(162.41,182.95) 162.22,183.14 v2(162.22,186) 162.22,188.73 v2(162.09,188.86)
VR_CSREFA: length 15.2
  TOP w0.203: U10.22 173.75,181.97 174.14,182.37 175.44,182.37 176.22,181.58 C92.2
  TOP w0.254: v2(174.6,188.92) 174.6,189.59 R56.1 ; C92.2 176.03,181.31 175.33,181.31 v2(174.94,181.69) ; R80.1 v2(176.22,184.73)
  BOTTOM w0.254: v2(174.6,188.92) 174.6,188.03 176.22,186.41 v2(176.22,184.73) 176.22,184.06 174.94,182.79 v2(174.94,181.69)
VR_CSSUM: length 26
  TOP w0.203: 164.57,181.57 U10.45
  TOP w0.254: v2(156.95,182.25) 156.41,182.79 R99.2 154.66,183.71 154.09,184.28 154.09,185.64 154.32,185.87 R77.1 156.34,187.71 R63.1 157.39,188.28 158.44,187.24 R73.1 ; 164.57,181.57 164.42,181.43 162.54,181.43 162.03,180.92 C98.2 C87.2 161.74,182.6 161.39,182.95 v2(159.8,182.95)
  BOTTOM w0.254: v2(159.8,182.95) 159.36,183.39 157.71,183.39 156.95,182.63 v2(156.95,182.25)
VR_CSSUMA: length 12.5
  TOP w0.203: 174.16,181.57 U10.21
  TOP w0.254: 174.16,181.57 174.24,181.57 175.4,180.41 R112.1 176.66,179.9 178.6,179.9 178.79,179.71 C101.2 C100.2 181.27,182.98 R102.2 R87.1
VR_DIFF: length 4.4
  TOP w0.203: U10.50 166.52,179.57 166.09,179.14 165.96,179.14
  TOP w0.254: R125.1 R119.1 165.96,179.14
VR_DIFF_R: length 1.3
  TOP w0.254: R125.2 C107.1
VR_DIFFA: length 12.3
  TOP w0.203: 173.41,179.57 U10.16
  TOP w0.254: 173.41,179.57 173.48,179.57 174.1,178.96 175.62,177.44 175.62,176.51 R139.1 176.73,175.39 180.7,175.39 182.22,176.92 R127.1
VR_DIFFA_R: length 1.1
  TOP w0.254: C108.1 R127.2
VR_DRON: length 201.3
  TOP w0.203: U10.35 169.23,184.66 168.35,185.54 168.35,187.81 168.95,188.41 v2(168.95,188.54)
  TOP w0.254: R288.1 v2(188,118.27) ; R178.1 117.6,168.97 118.67,168.97 v2(119.1,168.53) ; R264.1 v2(188,134.75) ; R347.1 v2(191.43,97.35) ; v2(132.56,168.53) 132.75,168.34 R179.1
  BOTTOM w0.254: v2(191.43,97.35) 191.87,97.8 v3(191.87,98.56) 191.87,101.61 188.89,104.59 188.89,116.27 188,117.16 v2(188,118.27) 188,118.56 191,121.56 191,124.21 189.84,125.37 189.84,132.66 188,134.5 v2(188,134.75) 191.11,137.86 191.11,142.88 188.63,145.36 188.63,153.23 184.89,156.98 176.95,156.98 175.36,158.57 175.36,165.68 184.47,174.78 184.47,184.7 178.98,190.19 170.09,190.19 168.95,189.05 v2(168.95,188.54) 168.06,188.54 164.79,191.8 156.78,191.8 143.1,178.12 143.1,172.09 140.63,169.61 138.02,169.61 137.33,168.92 132.94,168.92 v2(132.56,168.53) v2(119.1,168.53)
VR_DRON1: length 3.4
  TOP w0.254: U17.3 137.2,168.03 136.89,168.34 R179.2
VR_DRON1A: length 3.4
  TOP w0.254: U23.3 188.57,120.71 187.81,119.96 v2(187.66,119.96) 187.3,119.6 R288.2
  BOTTOM w0.102: v2(187.66,119.96) 187.25,120.36 v3(187.25,120.69)
VR_DRON2: length 3.3
  TOP w0.102: v3(115.35,169.36) 115.77,169.36 R178.2
  TOP w0.254: R178.2 116.91,168.22 117.51,168.22 117.77,167.96 U16.3
VR_DRON2A: length 1.3
  TOP w0.254: U25.3 189.26,97.99 189.62,97.64 R347.2
VR_DRON3: length 2.1
  TOP w0.254: R264.2 188.57,137.07 U21.3
VR_EN_C1: length 5.8
  TOP w0.102: v1(5.36,143.64) Q21.D 7.53,143.07 Q22.G 9.06,141.55 R246.1
VR_EN_C2: length 6
  TOP w0.102: R269.1 9.25,135.07 8.48,134.31 Q24.D 6.52,135.32 Q23.G v1(5.31,135.9)
VR_ENABLE: length 520.9
  TOP w0.102: R252.1 74.91,140.02 77.24,142.36 77.24,148.13 74.94,150.42 67.36,150.42 v2(66.15,151.64) ; v2(157.28,26.36) 157.28,27.83 157.71,28.26 158.98,28.26 159.36,28.64 159.36,30.42 159.09,30.69 158.15,30.69 156.51,32.33 152.77,32.33 151.88,33.22 150.18,33.22 R479.2 ; U18.6 102.25,167.98 102.79,168.53 102.79,170.43 v2(102.34,170.88) 98.9,170.88 97.25,169.24 93.05,165.03 85.9,165.03 85.19,165.74 82.26,165.74 70.21,153.69 v2(69.25,153.69) 64.97,153.69 61.87,150.59 53.96,150.59 51.61,148.24 33.92,148.24 32.44,146.77 29.8,146.77 25.34,151.22 22.33,151.22 21.01,152.55 20.04,152.55 18.8,151.3 18.34,151.3 18.06,151.02 17.04,151.02 16.82,151.25 16.54,151.25 15.49,152.29 13.84,152.29 12.64,151.09 12.64,141.01 R251.2 12.1,138.05 12.1,120.34 11.28,119.51 C265.2 9.88,119.51 Q28.C
  TOP w0.203: U10.2 168.03,177.68
  TOP w0.254: 168.03,177.68 167.88,177.53 167.88,177.52 165.18,174.82 164.34,174.82 C124.2 163.3,173.77 163.3,172.25 R163.1 162.42,171.74 160.83,173.33 R144.2 159.2,173.33 153.07,179.46 153.07,185.49 v2(150.63,187.93)
  BOTTOM w0.102: v2(66.15,151.64) 68.2,153.69 v2(69.25,153.69) ; v2(102.34,170.88) 102.79,170.43 108.5,170.43 109.2,169.74 137.1,169.74 139.04,171.68 139.04,176.98 149.99,187.93 v2(150.63,187.93) 155.99,193.3 173.27,193.3 174.16,194.19 176.95,194.19 187.24,183.9 187.24,174.31 190.98,170.57 195.17,170.57 197.8,167.94 197.8,100.11 192.82,95.13 190.41,95.13 188.61,93.33 188.61,65.25 v3(189.27,64.59) 191.43,62.43 191.43,53.22 184.76,46.56 184.76,41.85 186.54,40.07 186.54,38.68 179.98,32.12 177.13,32.12 173.84,28.83 172.56,28.83 170.4,26.68 165.08,26.68 164.06,27.69 158.61,27.69 v2(157.28,26.36)
VR_FB: length 10.3
  TOP w0.203: U10.49 166.35,179.97 166.02,179.65 165.71,179.65
  TOP w0.254: 165.71,179.65 163.68,179.65 163.17,179.14 R119.2 C103.1 160.79,178.19 C107.2 160.47,178 R118.2 R113.1
VR_FBA: length 11.9
  TOP w0.203: U10.17 173.39,179.97
  TOP w0.254: C109.1 180.06,177.08 C108.2 ; C109.1 180.03,176.79 179.2,175.97 R139.2 176.16,176.92 R128.2 176.16,177.44 173.62,179.97 173.39,179.97 ; C109.1 R123.1
VR_HOT_L: length 67.8
  TOP w0.102: U10.12 172.03,176.94 174.02,174.95 174.6,174.95 174.98,174.57 174.98,172.25 R157.1 176.02,171.21 176.02,170.22 176.2,170.05 176.2,168.12 175.25,167.16 167.91,167.16 167.18,167.9 v2(166.6,167.9) ; v2(165.96,136.78) 166.38,137.2 R259.2 165.77,138.28 164.32,138.28 C233.1 R258.1
  BOTTOM w0.102: v2(165.96,136.78) 165.96,137.48 155.73,147.72 155.73,155.09 163.7,163.06 163.7,165.07 166.54,167.9 v2(166.6,167.9)
VR_ILIM: length 3.2
  TOP w0.203: 165.58,180.92 165.84,181.17 U10.46
  TOP w0.254: R110.1 165.58,180.92
VR_ILMA: length 4
  TOP w0.203: U10.20 173.58,181.17
  TOP w0.254: 173.58,181.17 174.1,181.17 175.94,179.33 R117.1
VR_IMAX: length 6.3
  TOP w0.203: U10.36 168.83,184.59 168,185.43 168,188.54 168.92,189.46 R55.2
VR_IMAXA: length 3.1
  TOP w0.203: 171.63,184.93 U10.29
  TOP w0.254: 171.63,184.93 171.63,185.6 171.3,185.93 R66.2
VR_IOUT: length 7.9
  TOP w0.203: U10.1 167.63,177.88 167.23,177.49
  TOP w0.254: R145.2 C123.2 163.58,175.2 164.98,175.2 167.23,177.46 167.23,177.49
VR_IOUTA: length 8.4
  TOP w0.203: U10.13 172.43,177.42
  TOP w0.254: 172.43,177.42 172.43,176.98 174.08,175.33 174.7,175.33 175.62,174.41 C128.2 176.17,173.72 176.17,172.2 R158.2
VR_PROG2: length 4.8
  TOP w0.203: U10.10 171.23,177.56
  TOP w0.254: 171.23,177.56 171.23,176.38 R143.2
VR_PWM1: length 51.4
  TOP w0.203: U17.2 137.7,168.37 138.26,168.93 v2(138.28,168.93) ; v2(168.89,187.59) 168.76,187.46 168.76,185.6 169.63,184.73 U10.34
  BOTTOM w0.203: v2(138.28,168.93) 139.5,168.93 140.02,168.41 141.01,168.41 143.68,171.07 143.68,177.89 157.23,191.45 162.98,191.45 166.84,187.59 v2(168.89,187.59)
VR_PWM1_BST_R: length 1.8
  TOP w0.508: C167.2 139.48,164.85 140.06,165.42 R183.2
VR_PWM1_HG: length 10.4
  TOP w0.508: v2(147.61,164.85) 147.68,164.92 R197.1
  BOTTOM w0.508: v2(138.79,165.77) v3(140.06,165.77) 146.7,165.77 v2(147.61,164.85)
VR_PWM1_HG_R: length 4.9
  TOP w0.635: R197.2 147.8,163.14 v2(147.49,162.82) R199.2 146.5,163.23 146.41,163.33 QCH1.G
  BOTTOM w0.102: v2(147.49,162.82) 146.94,163.37 v3(146.69,163.37)
VR_PWM1_LG:
  vias: v1(135.69,164.94)
VR_PWM1_LG_R: length 20.2
  TOP w0.635: QCL1.G v2(132.7,150.25) ; QCL4.G v2(132.7,158.76) ; R192.2 v2(132.5,163.53)
  BOTTOM w0.635: v2(132.7,150.25) 133.34,150.25 v3(133.76,150.67) 134.09,151 134.09,156.66 132.7,158.04 v2(132.7,158.76) 133.58,158.76 134.09,159.26 134.09,162.63 133.19,163.53 v2(132.5,163.53)
VR_PWM1_VCC: length 1.6
  TOP w0.508: C156.2 135.26,167.23 134.85,166.82 R184.1
VR_PWM1A: length 108.1
  TOP w0.203: U10.30 171.23,185.12 170.66,185.68 170.66,188.47 172.59,190.41 v2(172.59,190.82)
  TOP w0.254: v2(189.9,118.18) 189.27,117.54 187.17,117.54 186.67,118.05 186.67,120.03 187.15,120.52 187.8,120.52 188.07,120.79 U23.2
  BOTTOM w0.254: v2(172.59,190.82) 173.74,191.97 177.78,191.97 186.02,183.73 186.02,174.05 190.49,169.58 194.56,169.58 196.79,167.34 196.79,125.06 v3(190.98,119.26) v2(189.9,118.18)
VR_PWM1A_BST: length 2.3
  TOP w0.102: R285.1 186.16,120.26 v2(185.85,119.96)
  BOTTOM w0.102: v2(185.85,119.96) 185.37,119.47 v3(185.37,119.22)
VR_PWM1A_BST_R: length 3.9
  TOP w0.102: R285.2 v2(184.38,119.96)
  TOP w0.508: C260.2 R285.2
  BOTTOM w0.102: v2(184.38,119.96) 184.02,120.31 v3(184.02,120.77)
VR_PWM1A_HG:
  vias: v1(187.2,123.89)
VR_PWM1A_HG_R: length 3.2
  TOP w0.508: R280.2 R278.2 184.79,126.28 185.33,126.82 QCGH1.G
VR_PWM1A_LG: length 10.9
  TOP w0.508: R268.1 v2(185.9,133.61)
  BOTTOM w0.508: v2(185.9,133.61) 185.9,133.48 187.62,131.77 187.62,125.99 v3(188,125.61) v2(188.7,124.91)
VR_PWM1A_LG_R: length 20.4
  TOP w0.508: QCGL1.G 171.49,136.66 172.31,137.48 179.36,137.48 180,136.85 ; 180,136.85 180.63,137.48 183.17,137.48 183.74,136.91 185.4,136.91 R268.2 ; 180,136.85 QCGL3.G
VR_PWM1A_VCC: length 1.8
  TOP w0.508: C262.2 190.48,120.62 R286.1
VR_PWM2: length 71
  TOP w0.203: U16.2 v2(118.27,168.41) ; v2(169.32,186.82) 169.32,185.54 170.03,184.83 U10.33
  BOTTOM w0.203: v2(118.27,168.41) 118.87,167.81 133.63,167.81 134.09,168.27 139.47,168.27 139.93,167.81 141.24,167.81 144.25,170.82 144.25,177.81 157.56,191.12 162.19,191.12 166.48,186.82 v2(169.32,186.82)
VR_PWM2_BST: length 1.3
  TOP w0.102: v3(120.69,169.11) R182.1
VR_PWM2_BST_R: length 1.6
  TOP w0.508: C166.2 120.94,165.23 120.69,165.49 R182.2
VR_PWM2_HG: length 12.5
  TOP w0.635: v2(130.66,165.93) 130.28,165.55 R196.1
  BOTTOM w0.635: v2(130.66,165.93) 130.59,165.99 120.78,165.99 v3(120.55,165.77) v2(119.42,165.77)
VR_PWM2_HG_R: length 3.8
  TOP w0.635: R196.2 129.71,163.14 129.04,163.8 R198.2 127.96,164.6 QCH2.G
VR_PWM2_LG: length 7.9
  TOP w0.635: R218.1 113.45,162.63 114.66,163.84 115.55,163.84 v3(116.56,164.85)
VR_PWM2_LG_R: length 13
  TOP w0.635: QCL2.G v2(117.01,149.42) ; v2(115.15,157.61) 115.15,158.67 R218.2 QCL5.G
  BOTTOM w0.635: v2(117.01,149.42) 117.32,149.74 v3(117.32,155.14) 117.32,155.44 v2(115.15,157.61)
VR_PWM2_VCC: length 3.1
  TOP w0.102: v3(113.45,168.03) R181.1
  TOP w0.508: R181.1 115.26,167.61 C153.2
VR_PWM2A: length 128.2
  TOP w0.203: v2(171.55,190.9) 171.55,189.87 170.28,188.6 170.28,185.57 170.83,185.02 U10.31
  TOP w0.254: U25.2 v2(188.76,97.54)
  BOTTOM w0.254: v2(188.76,97.54) 189.78,96.53 v3(189.97,96.53) 193.02,96.53 197.21,100.72 197.21,167.52 194.73,170 190.67,170 186.44,174.22 186.44,183.88 177.76,192.55 173.48,192.55 171.83,190.9 v2(171.55,190.9)
VR_PWM2A_BST:
  vias: v1(187.33,97.76)
VR_PWM2A_BST_R: length 2.8
  TOP w0.102: C337.2 v1(183.31,98.88)
  TOP w0.508: C337.2 184.38,98.04 184.19,97.85 R348.2
VR_PWM2A_HG: length 2.8
  TOP w0.305: U25.8 188.26,100.78 187.94,101.11 187.94,101.52
  TOP w0.508: 187.94,103 v1(187.94,101.54) 187.94,101.52
VR_PWM2A_HG_R: length 3.4
  TOP w0.508: QCGH2.G 186.86,105.1 186.32,104.56 R328.2 185.84,103.32 R332.2
VR_PWM2A_LG: length 5.3
  TOP w0.508: R340.1 185.97,100.67 v2(186.86,101.55)
  BOTTOM w0.508: v2(190.06,101.35) 190.06,101.55 189.41,102.2 v3(187.87,102.2) 187.5,102.2 v2(186.86,101.55)
VR_PWM2A_LG_R: length 13
  TOP w0.508: v2(183.21,100.53) R340.2 QCGL4.G ; v2(176.31,101.35) 175.68,101.99 QCGL2.G
  BOTTOM w0.508: v2(183.21,100.53) 183.21,101.63 v3(182.86,101.99) 182.41,102.43 177.39,102.43 v2(176.31,101.35)
VR_PWM2A_VCC: length 3
  TOP w0.102: R345.1 v1(193.62,98.75)
  TOP w0.508: R345.1 192.03,98.46 C336.2
VR_PWM3: length 86.6
  TOP w0.203: v2(170.28,189.36) 169.9,188.98 169.9,185.45 170.43,184.93 U10.32
  TOP w0.254: U21.2 188.07,137.68 v2(187.87,137.48)
  BOTTOM w0.254: v2(187.87,137.48) v3(189.08,137.48) 189.33,137.48 190.54,138.69 190.54,142.56 188.06,145.04 188.06,152.91 184.57,156.41 176.7,156.41 174.98,158.12 174.98,165.84 184.09,174.94 184.09,184.54 178.82,189.81 170.73,189.81 v2(170.28,189.36)
VR_PWM3_BST_R: length 1.7
  TOP w0.508: C228.2 R255.2
VR_PWM3_HG:
  vias: v1(187.15,141.12)
VR_PWM3_HG_R: length 3.4
  TOP w0.508: R245.2 R243.2 184.73,143.42 185.27,143.96 QCH3.G
VR_PWM3_LG: length 9.2
  TOP w0.508: R240.1 v2(185.9,149.23)
  BOTTOM w0.508: v2(185.9,149.23) v3(185.9,147.77) 185.9,144.66 v2(188.44,142.12)
VR_PWM3_LG_R: length 20.7
  TOP w0.508: v2(185.65,153.04) 185.9,152.79 R240.2 ; QCL6.G v2(180,153.99) 180,155.07 179.11,155.96 172.38,155.96 171.49,155.07 QCL3.G
  BOTTOM w0.508: v2(180,153.99) 180.95,153.04 v3(184.63,153.04) v2(185.65,153.04)
VR_PWM3_VCC: length 1.6
  TOP w0.508: R265.1 189.97,137.36 C231.2
VR_READY: length 250.9
  TOP w0.102: v2(9.63,99.28) 8.78,98.43 6.39,98.43 5.94,98.88 R341.1 ; v2(145.33,182.31) 150.09,182.31 151.11,181.3 151.11,179.14 158.22,172.03 160.63,172.03 161.39,171.26 164.26,168.39 164.27,168.39 164.63,168.03 v2(165.01,168.03) ; v2(24.18,150.7) 25.54,150.7 29.7,146.54 32.54,146.54 34.01,148.01 51.71,148.01 54.06,150.36 61.96,150.36 64.76,153.16 70,153.16 82.35,165.51 85.1,165.51 85.81,164.8 93.14,164.8 98.43,170.09 R173.2 v2(101.26,170.09) ; Q27.C 8.81,122.04 v2(11.51,122.04) ; U10.6 169.63,177.28 168.69,176.35 168.69,174.6 C125.2 167.92,173.83 167.92,172.84 167.89,172.81 167.89,172.23 R167.1 167.81,171.17 167.81,170.57 167.49,170.25 167.49,169.68 v2(167.17,169.36)
  BOTTOM w0.102: v2(101.26,170.09) 108.21,170.09 v3(109.32,168.98) 109.77,168.53 111.04,168.53 112.01,169.51 137.19,169.51 139.27,171.59 139.27,176.25 v2(145.33,182.31) ; v2(165.01,168.03) 166.35,169.36 v2(167.17,169.36) ; v2(9.63,99.28) 10.01,99.66 10.01,104.08 10.96,105.03 10.96,107.13 12.42,108.59 12.42,121.13 v2(11.51,122.04) 12.04,122.57 12.04,139.01 13.56,140.53 14.79,140.53 15.85,141.59 19.2,141.59 20.23,142.63 20.99,142.63 21.67,143.3 21.67,146.53 24.18,149.05 v2(24.18,150.7)
VR_ROSC: length 4.2
  TOP w0.203: 170.43,177.47 U10.8
  TOP w0.254: R149.2 171.04,175.08 170.43,175.69 170.43,177.47
VR_SCLK: length 4.8
  TOP w0.102: R148.1 168.12,175.17 168.12,176.36 169.23,177.46 U10.5
VR_SDIO: length 5.6
  TOP w0.102: R146.1 165.3,174.28 168.43,177.41 U10.3
VR_TSENSE: length 6.5
  TOP w0.203: U10.37 168.43,184.49 167.62,185.3 167.62,186.28 C63.1
  TOP w0.254: R54.2 167.55,189.01 167.55,187.74 C63.1
VR_TSENSE_NTC: length 42.4
  TOP w0.254: R53.2 v2(167.3,190.41) R54.1 ; RT1.2 v2(140.25,170.22)
  BOTTOM w0.254: v2(140.25,170.22) 140.25,176.09 156.34,192.18 165.55,192.18 167.3,190.43 v2(167.3,190.41)
VR_TSENSEA: length 8.6
  TOP w0.203: U10.11 171.63,177.29
  TOP w0.254: R156.2 173.93,171.87 173.58,172.22 173.58,172.92 173.84,173.17 173.84,173.65 C127.1 174.38,174.38 174.16,174.38 171.63,176.91 171.63,177.29
VR_TSENSEA_NTC: length 53.1
  TOP w0.254: RT3.2 v2(187.71,133.58) ; v2(175.16,169.54) 174.92,169.77 R176.2 R156.1
  BOTTOM w0.254: v2(187.71,133.58) 186.98,134.31 186.98,137.61 187.87,138.5 189.46,138.5 189.97,139.01 189.97,142.31 187.49,144.79 187.49,152.66 184.25,155.9 176.44,155.9 174.47,157.87 174.47,168.85 v2(175.16,169.54)
VR_VCC: length 9.5
  TOP w0.203: 170.03,177.62 U10.7
  TOP w0.254: 169.9,176.22 169.9,176.92 170.03,177.04 170.03,177.62
  TOP w0.508: R175.1 169.14,170 169.14,173.49 C131.2 169.9,176.22
VR_VRAMP: length 8.6
  TOP w0.203: 170.83,177.32 U10.9
  TOP w0.254: R162.1 R161.2 171.68,172.44 171.68,173.77 C126.1 172.19,174.69 170.83,176.05 170.83,177.32
VR_VSN: length 6.9
  TOP w0.203: U10.52 167.12,178.45
  TOP w0.254: 167.12,178.45 167.12,178.36 166.5,177.74 165.81,177.74 164.28,176.22 163.58,176.22 C116.2 R141.2
VR_VSNA: length 9.5
  TOP w0.203: U10.14 172.94,178.2
  TOP w0.254: 172.94,178.2 172.94,177 174.17,175.77 175.06,175.77 176.55,174.28 C129.2 177.29,173.75 177.29,172.16 R159.2
VR_VSP: length 6.8
  TOP w0.203: 166.47,178.89 166.76,179.17 U10.51
  TOP w0.254: R133.2 162.25,177.36 163.52,177.36 C111.2 164.19,176.85 165.65,178.31 165.9,178.31 166.47,178.89 166.47,178.89
VR_VSPA: length 8.8
  TOP w0.203: U10.15 173.3,179.17
  TOP w0.254: 173.3,179.17 174.98,177.49 174.98,176.39 176.42,174.95 177.24,174.95 177.9,174.28 C130.2 R150.2
VRALERT_L: length 22.8
  TOP w0.089: PCH1.BD23 38.29,89.01 38.21,89.01 37.34,88.14 36.97,88.14 35.04,86.21 35.04,84.76 34.87,84.59 34.87,82.01 34.14,81.27 34.14,80.74 32.56,79.16 32.02,79.16
  TOP w0.102: R386.1 28.84,73.13 28.52,73.44 28.52,77.89 29.79,79.16 32.02,79.16
VRD_C1: length 3.2
  TOP w0.102: Q32.G 5.12,101.73 4.93,101.54 v1(4.93,101.16) 4.86,101.1 C332.2 R341.2
VRD_C2: length 6.9
  TOP w0.102: R342.2 7.02,100.59 v1(6.52,101.1) 6.01,101.61 6.01,103.83 6.13,103.96 Q32.D 5.13,105.59 Q31.G
VRD_C4_1: length 5.3
  TOP w0.102: Q31.D 6.15,109.16 6.26,109.28 R317.1 ; R316.1 5.31,111.04 R317.1 ; R317.1 6.66,110.08 6.88,109.86 R319.2 7.37,110.62 v1(7.52,110.76)
VRD_THERMDA: length 250.8
  TOP w0.203: U35.86 186.61,25.7 186.72,25.59
  TOP w0.254: 186.72,25.59 188.23,24.07 C506.1 v2(188.92,23.37) ; Q20.C 138.79,170.5 v2(137.77,171.52) Q20.B 135.87,171.52 135.42,171.07 C140.1
  BOTTOM w0.254: v2(137.77,171.52) 137.31,171.98 137.31,176.14 155.04,193.87 172.93,193.87 173.83,194.77 177.44,194.77 187.83,184.38 187.83,174.57 191.27,171.14 195.57,171.14 198.36,168.34 198.36,99.3 196.27,97.2 196.27,56.56 187.3,47.6 187.3,41.95 187.81,41.44 187.81,28.01 v3(187.53,27.73) 187.81,27.45 187.81,25.82 189.15,24.48 189.15,23.61 v2(188.92,23.37)
VRD_THERMDC: length 248
  TOP w0.254: C140.2 136.53,169.26 Q20.E v2(136.75,170.5) ; SP20.2 191.05,24.07 C506.2 v2(189.87,23.34)
  BOTTOM w0.254: v2(136.75,170.5) 136.75,176.37 154.81,194.43 172.7,194.43 173.6,195.33 177.68,195.33 188.39,184.62 188.39,174.8 191.5,171.7 195.8,171.7 198.92,168.58 198.92,99.07 196.83,96.97 196.83,56.33 187.86,47.36 187.86,42.18 188.37,41.67 188.37,29.76 v3(188.65,29.48) 188.37,29.2 188.37,26.05 189.71,24.71 189.71,23.5 v2(189.87,23.34)
VREF: length 4.3
  TOP w0.254: C34.1 20.73,192.4 v3(20.73,190.5) 20.48,190.25 20.48,189.98 20.46,189.95 CODEC.27
VSA_GSENS: length 174.6
  TOP w0.102: v2(74.07,115.54) 74.4,115.21 74.4,111.68 74.85,111.22 74.85,110.69 75.36,110.18 SP15.1 77.01,110.18 79.25,112.41 79.25,117.51 81.86,120.12 81.86,124.05 82.96,125.14 86.39,125.14 89.18,127.93 89.18,134.61 90.32,135.75 90.32,137.61 v2(92.76,140.05) ; SP7.1 82.08,142.75 82.65,142.18 v2(82.65,141.48) ; v2(86.97,165.84) 87.15,166.02 88.11,166.02 88.77,165.36 92.75,165.36 101.32,173.93 105.04,173.93 105.25,173.73 105.25,173.47 SP1.1
  BOTTOM w0.102: v2(92.76,140.05) 91.44,141.37 82.77,141.37 v2(82.65,141.48) ; v2(74.07,115.54) 73.58,116.02 70.77,116.02 65.46,110.71 64.61,110.71 64.05,111.27 62.31,111.27 53.57,120.01 53.57,127.83 v3(52.49,128.91) 52.49,140.91 67.58,156 71.38,156 74.96,159.58 78.46,159.58 82.17,163.29 83.28,163.29 85.35,165.36 86.49,165.36 v2(86.97,165.84)
VSA_PWRGD: length 2.6
  TOP w0.102: R173.1 100.53,169.11 v1(100.53,168.17) 101.45,167.25 U18.8
VSA_SENS: length 163.1
  TOP w0.102: SP2.1 105.5,173.63 105.5,173.84 105.15,174.19 101.22,174.19 92.64,165.61 88.88,165.61 88.14,166.35 86.76,166.35 86.28,165.87 v2(86.13,165.87) ; v2(73.33,115.51) 74.14,114.7 74.14,111.14 v2(74.32,110.97) ; CPU.AD5 v7(107.64,111.45)
  BOTTOM w0.102: v2(86.13,165.87) 85.88,165.61 85.24,165.61 83.17,163.55 82.05,163.55 78.33,159.84 74.85,159.84 71.27,156.25 67.48,156.25 51.74,140.52 51.74,128.58 53.32,127.01 53.32,119.91 62.21,111.02 62.42,111.02 63.95,111.02 64.51,110.46 65.57,110.46 70.85,115.74 73.1,115.74 v2(73.33,115.51) ; v7(107.64,111.45) 107.49,111.45 106.78,112.16 95.05,112.16 88.81,105.92 v3(76.4,105.92) 76.18,105.92 73.89,108.21 73.89,110.53 v2(74.32,110.97)
VTT_EN: length 111.7
  TOP w0.254: R495.1 v2(139.68,29.34) ; v2(184.63,91.06) D16.3 189.08,91.06 190.16,89.99 R357.2
  BOTTOM w0.254: v2(139.68,29.34) 139.93,29.34 144.56,33.98 179.77,33.98 181.62,35.83 181.62,51 184.06,53.44 184.06,55.06 188.39,59.38 188.39,60.92 185.59,63.72 v3(185.59,89.67) 185.59,90.11 v2(184.63,91.06)
VTT_EN_N1: length 9.9
  TOP w0.102: R355.2 v1(190.76,92.17)
  TOP w0.254: QN2.1 183.63,92.22 184.06,92.65 QN1.D 185.65,92.65 186.41,91.89 189.59,91.89 190.22,91.26 R355.2
VTT_EN_N2: length 6.1
  TOP w0.102: R349.2 v1(181.27,93.29)
  TOP w0.254: QN1.G 185.71,94.43 185.27,93.99 182.57,93.99 C341.2 R349.2
WAKE_L: length 7.9
  TOP w0.102: U19.21 59.8,161.6 58.5,160.29 58.5,157.4 58.27,157.17 R225.2 R226.1 60.17,157.01 v1(60.25,157.09)
WRST_L: length 5.5
  TOP w0.102: R575.1 176.85,11.59 C569.1 176.63,12.21 177.24,12.82 v1(177.24,14.09) U35.47
XCLK_BIASREF: length 10.5
  TOP w0.102: R327.2 64.94,104.4 64.17,103.64 64.17,102.75 62.9,101.48 59.03,101.48 57.74,100.19 PCH1.E1
XTAL1: length 18
  TOP w0.152: Y1.2 74.46,165.26 C161.1 74.37,164.68 74.14,164.46 72.29,164.46 71.98,164.15 71.98,163.9 71.39,163.3 62.85,163.3 62.14,164.02 U19.28
XTAL2: length 17.2
  TOP w0.152: U19.29 62.2,164.42 62.99,163.62 71.22,163.62 71.6,164 71.6,164.23 71.4,164.43 69.83,164.43 69.48,164.79 C160.1 69.38,165.26 Y1.1
XTAL_24M_IN: length 11.5
  TOP w0.102: PCH1.A6 59.6,97.63 61.92,99.95 64.14,99.95 R339.1 C331.1 66.52,100.25 X1.2
XTAL_24M_OUT: length 13.9
  TOP w0.102: PCH1.A5 61.8,100.34 63.57,100.34 R339.2 65.27,102.03 65.27,103.62 C328.1 66.02,104.59 66.55,105.13 X1.1
N18066055: length 8.2
  TOP w0.102: F_AUDIO.4 9.39,184.33 9.39,183.01 10.87,181.54 C99.2 10.87,179.93 11.31,179.48 R122.1
N18833916: length 6.6
  TOP w0.102: R592.1 R591.2 109,5.85 F_PANEL.7
N18839810: length 5.2
  TOP w0.102: v1(158.47,22.62) 158.41,22.69 D23.P
  TOP w0.254: U33.10 156.7,25.09 156.95,25.34 157.96,25.34 158.41,24.9 D23.P
N32097828: length 2.2
  TOP w0.102: U4.11 111.41,194.86 R28.1
N32097831: length 3.9
  TOP w0.102: TP2.1 112.42,195.14 110.02,195.14 109.9,195.26 U4.12
N32097834: length 2.1
  TOP w0.102: TP1.1 110.9,195.4 110.16,195.4 109.9,195.66 U4.13
N32111832: length 5
  TOP w0.102: U24.12 66.63,114.52 67.34,113.81 v1(67.87,113.81) 68.11,113.57 68.11,113.04 69.37,111.78 C307.1
N32111846: length 2.8
  TOP w0.102: C306.1 67.72,112.25 v1(67.31,112.67) 67.31,113.18 66.77,113.72 U24.10
N32196079: length 2.5
  TOP w0.508: C590.1 49.6,4.58 v2(48.95,4.58) 47.98,4.58
  BOTTOM w0.102: v3(48.08,4.58) v2(48.95,4.58)
N32196301: length 4.8
  TOP w0.508: D27.N 52.09,7.88 C587.1 53.35,8.2 53.06,8.48 v1(53.06,8.96) 52.74,9.28 R583.2
N32196344: length 1.3
  TOP w0.254: C591.1 60.08,12.9 R584.2
N32208973: length 13.7
  TOP w0.254: v2(101.26,169.07) 101.26,169.2 R174.2
  BOTTOM w0.254: v2(105.45,162.25) 105.77,162.25 107.09,163.57 107.09,167.09 105.1,169.07 v3(102.72,169.07) v2(101.26,169.07)
N32209107: length 2.4
  TOP w0.203: R174.1 102.15,168.51 v1(101.85,168.21) U18.7
N32209109:
  vias: v2(101.77,156.72) v2(102.02,159.71) v2(102.02,155.01) v2(104.37,155.01) v2(104.88,156.53) v2(105.89,158.31) v2(106.4,155.01) v2(108.12,155.07) v2(108.31,157.61) v4(101.6,165.93) v4(101.6,163.55) v4(102.69,164.74)
N32209152: length 3
  TOP w0.508: C174.2 98.28,161.71 v2(98.6,161.38) 99.01,160.98 R208.1
  BOTTOM w0.102: v3(99.29,160.85) 98.76,161.38 v2(98.6,161.38)
N32209166: length 2.7
  TOP w0.102: v1(108.79,167.25) 109,167.04 C157.2
  TOP w0.508: C157.2 107.89,166.34 R189.2
N32209168: length 3.8
  TOP w0.203: U18.16 105.86,164.19 105.96,164.09
  TOP w0.508: 105.96,164.09 v2(106.48,164.09) 106.59,164.09 R189.1
  BOTTOM w0.102: v2(106.48,164.09) 105.96,163.57 v3(105.82,163.57)
N32209170: length 5.4
  TOP w0.203: U18.14 105.95,163.39
  TOP w0.508: 105.95,163.39 107.95,163.39 109,164.45 C157.1
N32209174: length 5.5
  TOP w0.102: v1(102.95,172.15) 103.26,171.84 R168.2
  TOP w0.203: U18.3 103.45,167.87
  TOP w0.254: 103.45,167.87 103.45,168.22 103.26,168.41 C144.1 R171.1 R168.2
N32209188: length 5.2
  TOP w0.254: SP2.2 106.12,172.38 R169.1 C139.2 v1(105.13,170.19) R171.2 C144.2
N32209268: length 3.9
  TOP w0.102: v1(97.54,167) 97.13,166.59 R187.1
  TOP w0.508: C154.2 98.43,166.12 R188.2 R187.1
N32209303: length 1.4
  TOP w0.203: U18.10 99.59,165.79 R188.1
N32209429: length 3.2
  TOP w0.203: U18.1 104.25,167.27 104.69,167.71
  TOP w0.254: C145.2 105.74,169.11 v1(105.16,168.52) 105.16,168.18 104.69,167.71
N32212142: length 2.8
  TOP w0.203: U22.1 78.85,136.04 79.88,137.07 C235.2
N32212212: length 13.7
  TOP w0.508: 84.07,131.39 84.07,134.6 82.78,135.9 82.78,136.59 81.26,138.12 v2(79.67,138.12) ; v2(77.06,139.57) R253.2
  BOTTOM w0.508: v2(77.06,139.57) 77.06,139.01 v3(77.57,138.5) 77.95,138.12 v2(79.67,138.12)
N32212317: length 2.4
  TOP w0.203: U22.7 76.45,137.28 R253.1
N32212362: length 2.8
  TOP w0.102: R276.1 v1(70.71,131.2)
  TOP w0.508: R276.1 71.92,131.93 71.83,132.03 C243.2
N32212384: length 1.3
  TOP w0.508: R272.2 83.22,132.91 82.98,132.66 C244.2
N32212394: length 2.5
  TOP w0.203: U22.16 80.3,133.01
  TOP w0.508: 80.3,133.01 81.35,133.01 R272.1
N32212396: length 2.5
  TOP w0.203: U22.14 80.24,132.21
  TOP w0.508: 80.24,132.21 81.97,132.21 C244.1
N32212408: length 5.5
  TOP w0.203: R248.1 C230.1 79.29,139.2 78.21,138.12 R254.2 78.64,137.46 78.64,136.96 78.05,136.37 U22.3
N32212414: length 5.1
  TOP w0.254: R249.1 R248.2 C230.2 C220.2 80.46,141.39 80.56,141.48 SP10.2
N32212486: length 2.5
  TOP w0.102: R271.2 v1(70.84,133.93)
  TOP w0.508: R271.2 71.76,134.12 C239.2
N32212535: length 2.9
  TOP w0.203: R271.1 73.4,134.61 U22.10
N32215527:
  vias: v2(121.83,25.98) v2(121.9,27.25) v2(122.53,31.25) v2(122.53,28.2) v2(123.8,28.2) v2(124.05,31.25) v2(124.82,27.25) v4(129.61,29.19) v4(130.8,28.1) v4(131.99,29.19)
N32228802: length 5.6
  TOP w0.508: U29.7 v2(97.18,29.66) 96.27,29.66 R496.2 96.21,29.66 C477.2 R497.2
  BOTTOM w0.102: v3(98.07,29.66) v2(97.18,29.66)
N32242153: length 3.1
  TOP w0.203: U31.1 47.97,27.12 49.95,25.13 C502.2
N32242206: length 12.5
  TOP w0.254: R483.2 50.49,31.31 49.49,31.31 v2(49.17,31)
  BOTTOM w0.254: v2(49.17,31) 48.86,31 48.16,30.3 48.16,28.38 47.74,27.96 42.09,27.96 v2(41.5,27.37)
N32242332: length 2.8
  TOP w0.203: R483.1 49.77,30.8 v2(49.23,30.26) 49.12,30.26 48.37,29.52 U31.7
N32242353:
  vias: v2(36.42,28.39) v2(36.63,27.42) v2(37.25,29.28) v2(38.52,29.47) v2(39.66,27.5) v4(44.46,29.76) v4(45.65,28.67) v4(46.84,29.76)
N32242377: length 1.4
  TOP w0.508: C462.2 41.89,32.49 R488.1
N32242399: length 1.5
  TOP w0.508: C508.2 44.46,22.68 45.95,22.68
N32242401: length 2.3
  TOP w0.203: U31.16 45.1,25.68
  TOP w0.508: R525.1 45.1,25.31 45.1,25.68
N32242403: length 2.8
  TOP w0.203: 44.3,25.64 U31.14
  TOP w0.508: 44.3,25.64 44.3,24.4 44.43,24.21 C508.1
N32242415: length 5.1
  TOP w0.203: R490.2 R503.1 C490.1 49.57,27.18 48.84,27.92 U31.3
N32242493: length 4.9
  TOP w0.102: R468.1 v2(47.79,35.01)
  TOP w0.508: R468.1 46.9,33.28 R476.2 47.09,32.87 C463.2
  BOTTOM w0.102: v2(47.79,35.01) 47.79,35.21 v3(47.3,35.71)
N32242529: length 1.4
  TOP w0.203: R476.1 46.69,31.71 U31.10
N32312087: length 8
  TOP w0.254: R554.2 v2(67.95,12.82) 67.95,12.67 67.73,12.45 QN5.C 67.29,10.86 67.29,9.91 66.84,9.47 66.37,9.47 65.89,8.98 65.89,8.45 65.63,8.2 Q86.5
  BOTTOM w0.102: v3(68.83,12.82) v2(67.95,12.82)
N32312093: length 5.4
  TOP w0.254: R565.2 R566.1 C592.1 63.13,12.32 QN5.B
N32396708: length 4.4
  TOP w0.254: R458.2 24.55,47.47 24.55,47.09 24.07,46.62 C417.1 25.06,46.42 25.38,46.74 D20.2
N32956468: length 8.8
  TOP w0.203: U39.24 38.77,160.76 38.43,161.11
  TOP w0.254: R190.1 C162.1 34.39,163.39 34.71,163.07 34.71,162.06 35.03,161.74 R191.2 35.31,162.15 35.66,162.5 36.55,162.5 36.81,162.25 36.81,161.8 37.19,161.42 37.79,161.42 38.1,161.11 38.43,161.11
N32957662: length 28
  TOP w0.508: v2(36.61,164.66) 37.15,164.12 C190.1 R195.1
  BOTTOM w0.508: v2(36.61,164.66) 37.57,165.61 44.68,165.61 46.52,163.77 46.52,156.6 45.19,155.26 40.36,155.26 v2(39.73,155.9)
  vias: v2(38.08,154.5) v2(38.08,153.1) v2(38.84,155.9) v2(38.96,154.5) v2(38.96,153.1)
N32999311: length 1.6
  TOP w0.508: C190.2 38.81,165.07 R212.2
N32999325: length 2.7
  TOP w0.203: U39.22 39.73,161.74 39.41,162.06
  TOP w0.508: 39.41,162.06 38.96,162.5 R212.1
N33018129: length 2.6
  TOP w0.203: U39.23 39.33,161.15 38.85,161.62 38.78,161.62
  TOP w0.508: 38.78,161.62 38.37,162.03 R195.2
N33074508: length 3.4
  TOP w0.203: U39.2 36.72,160.06 C164.2
  TOP w0.254: C164.2 35.38,158.72 R180.1
N33244839: length 8.6
  TOP w0.203: 36.98,158.36 37.22,158.36 37.72,158.86 U39.5
  TOP w0.254: R200.1 34.04,162.31 R194.2 34.04,160.01 34.52,159.53 34.52,158.57 34.96,158.12 35.82,158.12 C168.2 36.33,157.71 36.98,158.36
N33303939: length 2.3
  TOP w0.102: R616.2 68.02,6.96 67.79,7.18 67.79,7.94 67.54,8.2 Q86.2
N33304168: length 5.7
  TOP w0.102: C594.2 R620.1 R617.2 16.1,36.23 16.1,34.16 16.28,33.98 Q84.2
N33351619: length 1.1
  TOP w0.254: R623.2 C598.1
N33352335: length 5.6
  TOP w0.254: U38.9 59.42,9.14 59.72,9.44 59.72,10.43 59.16,10.99 58.62,10.99 R625.2 R624.2

## Copper pours and planes (outline as drawn)
+1V05_SA on TOP (solid shape): outline of 232 points within 108.66,111.58 112.85,121.1
+1V05_SA on TOP (solid shape): outline of 428 points within 101.13,133.61 125.26,153.99
+1V05_SA on BOTTOM (solid shape): outline of 1032 points within 101.19,112.59 127.29,153.93
+1V05_SA on PWR (solid shape): outline of 1438 points within 100.56,112.34 127.23,153.99
+2V5_DDRVPP on TOP (solid shape): outline of 264 points within 49.44,30.23 99.61,52.27
+3VSB on TOP (solid shape): 107.1,32.39 107.1,29.79 106.72,29.41 105.64,29.41 105.26,29.79 105.26,30.49 105.13,30.61 103.16,30.61 103.1,30.68 103.1,31.18 103.16,31.25 104.94,31.25 105.26,31.57 105.26,32.71 105.39,32.84 106.66,32.84
+3VSB on TOP (solid shape): 26.84,56.27 26.84,53.47 26.57,53.2 26.44,53.2 26.44,53.08 26.39,53.03 26.39,51.57 26.58,51.38 28.11,51.38 28.3,51.57 29.95,51.57 30.39,52.01 30.46,52.01 30.84,52.39 40.93,52.39 47.41,45.92 47.41,43.44 47.79,43.06 48.55,43.06 48.93,42.68 48.93,41.22 48.49,40.77 45.7,40.77 44.87,41.6 44.87,43.82 38.84,49.85 37.51,49.85 37.51,49.85 36.17,50.03 34.84,49.85 34.83,49.85 33.88,49.85 33.44,49.41 27.41,49.41 27.35,49.46 25.71,49.46 24.74,50.43 24.74,54.81 24.49,55.06 24.49,55.09 24.3,55.28 24.3,56.33 24.55,56.58 26.52,56.58
+3VSB on TOP (solid shape): 38.87,80.79 38.87,79.78 38.73,79.63 38.64,79.72 38.29,79.72 38.05,79.48 38.05,79.12 37.97,79.12 37.88,79.1 37.79,79.05 36.93,78.19 36.68,77.94 36.68,76.46 36.68,76.46 36.68,73.41 37.47,72.62 37.47,71.93 37.97,71.42 38.61,71.42 38.84,71.19 38.84,70.17 39.68,69.33 41.94,69.33 42.06,69.21 42.06,68.59 41.87,68.4 40.23,68.4 40.11,68.27 40.11,68.04 39.98,67.91 39.73,67.91 38.47,69.17 37.91,69.17 36.5,67.76 36.07,67.76 35.79,68.04 35.79,69.21 36.11,69.53 36.11,72.27 35.34,73.03 35.34,77.41 35.34,77.42 35.34,77.8 37.72,80.18 37.73,80.18 38.01,80.47 38.04,80.47 38.07,80.49 38.16,80.55 38.21,80.65 38.22,80.77 38.37,80.92 38.75,80.92
+3VSB on PWR (solid shape): outline of 1376 points within 47.27,29.58 109.96,51.77
+3VSB on PWR (solid shape): outline of 8362 points within 9.3,49.52 45.33,117.64
+5V_HDMI on TOP (solid shape): 169.71,203.84 169.71,202 169.39,201.68 168.5,201.68 167.55,202.63 159.55,202.63 158.41,201.49 157.84,201.49 157.65,201.68 157.65,203.78 157.96,204.09 169.46,204.09
+5VA on TOP (solid shape): 24.17,193.17 24.17,190.95 22.26,189.05 22.26,188.35 22.01,188.09 21.44,188.09 21.31,188.22 21.31,189.62 21.5,189.81 21.63,189.81 22.45,190.63 22.45,193.05 22.77,193.36 23.98,193.36
+5VA on TOP (solid shape): 13.5,190.06 13.5,187.01 13.31,186.82 13.26,186.82 13.25,186.83 13.12,186.85 12.99,186.83 12.98,186.82 12.74,186.82 11.85,187.71 11.85,188.28 11.66,188.47 11.66,190.25 11.98,190.57 12.99,190.57
+5VA on BOTTOM (solid shape): 24.23,191.97 24.23,190.76 22.39,188.92 15.41,188.92 14.2,187.71 13.12,187.71 12.8,188.03 12.8,190.06 13.18,190.44 22.01,190.44 22.52,190.95 22.52,192.03 22.64,192.16 24.04,192.16
+5VDUAL_1P0A on TOP (solid shape): 33.1,22.37 33.1,21.89 32.74,21.53 32.74,20.31 33.27,19.78 33.27,18.64 31.73,17.09 29.34,17.09 28.68,16.43 28.68,15.99 28.4,15.72 27.79,15.72 27.59,15.92 27.58,15.95 27.58,15.96 27.52,16.3 27.22,16.45 27.15,16.45 27.11,16.45 27.07,16.44 27.04,16.44 27.02,16.46 26.34,17.14 26.34,17.9 27.25,18.81 31.55,18.81 31.62,18.81 31.85,19.04 31.85,19.78 31.09,20.54 31.09,21.58 31.29,21.79 31.93,21.79 32.03,21.89 32.03,22.27 32.36,22.6 32.87,22.6
+5VSB on TOP (solid shape): 95.92,16.64 95.92,15.25 95.48,14.8 91.03,14.8 90.72,15.12 90.72,16.58 91.03,16.9 95.67,16.9
+5VSB on TOP (solid shape): 95.69,176.83 97.22,176.83 97.26,176.79 97.26,176.15 95.61,174.5 95.1,174.5 94.84,174.76 94.84,176.09 95.61,176.85 95.69,176.85
+5VSB on TOP (solid shape): 28.42,22.42 28.42,20.92 28.17,20.67 27.48,20.67 27.1,20.29 27.1,19.3 25.86,18.05 25.86,16.02 26.98,14.9 26.98,14.57 27.28,14.27 27.28,13.71 26.59,13.02 25.38,13.02 25.12,13.28 25.12,14.8 24.07,15.85 24.07,17.62 24.04,17.64 24.04,19.56 24.87,20.39 24.87,21.76 25.65,22.55 28.3,22.55
+5VSB on TOP (solid shape): outline of 106 points within 127.67,4.26 134.47,18.48
+5VSB on PWR (solid shape): outline of 272 points within 113.18,0.51 134.54,8.27
+12V on TOP (solid shape): 9.12,64.33 9.12,63.57 8.36,62.81 7.47,62.81 7.09,63.19 7.09,65.35 7.34,65.6 7.85,65.6
+12V on TOP (solid shape): 100.56,25.15 100.56,22.74 99.86,22.04 93.7,22.04 93.13,22.61 93.13,25.28 93.45,25.6 100.11,25.6
+12V on TOP (solid shape): 194.35,80.78 194.35,70.3 193.97,69.92 191.75,69.92 190.48,71.19 190.48,73.86 187.81,76.52 187.81,77.04 193.13,77.04 193.13,78.67 191.5,78.67 191.5,77.04 187.81,77.04 187.81,77.67 186.89,78.59 186.89,80.62 187.81,81.54 193.59,81.54
+12V on TOP (solid shape): outline of 169 points within 66.4,2.23 81.64,22.68
+12V on TOP (solid shape): outline of 171 points within 13.64,161.74 43.22,167.65
+12V on BOTTOM (solid shape): 17.97,165.17 18,165.15 18.02,165.12 18.02,163.89 19.34,163.89 19.34,165.12 19.35,165.15 19.39,165.17 20.93,165.17 21.18,164.92 21.18,162.88 20.93,162.63 20.04,162.63 19.15,161.74 14.83,161.74 14.81,161.77 14.8,161.78 14.65,162.02 14.4,162.18 14.39,162.18 13.64,162.93 13.64,163.77 13.96,164.09 14.96,164.09 16.04,165.17
+12V on PWR: outline of 403 points within 2.95,6.09 199.49,167.66
+12V on GND: 0.85,62.86 0.51,63.2 0.51,161.73 0.77,161.99 2.79,161.99 2.97,161.81 2.97,160.52 3.84,159.66 4.75,159.66 5.76,160.67 7.41,160.67 9.04,162.3 9.04,163.32 12.88,167.15 17.17,167.15 17.7,166.62 17.7,163.95 18.06,163.59 19.23,163.59 19.58,163.95 19.58,165.35 19.86,165.63 20.98,165.63 21.26,165.35 21.26,162.7 21.11,162.55 20.35,162.55 19.33,161.54 15.54,161.54 14.53,162.55 13.74,162.55 13.26,162.07 13.26,159.91 3.73,150.38 3.73,70.35 9.2,64.89 9.2,63.39 8.66,62.86
+12V_4P on TOP (solid shape): 195.56,169.36 195.56,164.03 195.3,163.77 187.43,163.77 185.9,162.25 179.87,162.25 178.54,163.58 178.54,166.44 180.6,168.5 182.8,168.5 182.8,168.44 182.81,168.38 182.83,168.33 182.85,168.27 182.88,168.22 182.92,168.17 182.96,168.13 183.01,168.1 183.07,168.07 183.12,168.05 183.18,168.04 183.24,168.04 183.3,168.04 183.36,168.06 183.41,168.08 183.44,168.09 184.13,168.09 184.15,168.09 184.21,168.1 184.26,168.11 184.31,168.14 184.35,168.17 184.4,168.2 184.43,168.24 184.46,168.29 184.48,168.34 184.5,168.39 184.51,168.44 184.51,168.5 184.5,168.55 184.48,168.6 184.46,168.65 184.43,168.7 184.4,168.74 184.35,168.78 184.31,168.81 184.26,168.83 184.21,168.84 184.15,168.85 184.13,168.85 183.44,168.85 183.41,168.87 183.36,168.89 183.3,168.9 183.24,168.9 183.18,168.9 183.12,168.89 183.07,168.87 183.01,168.84 182.96,168.81 182.92,168.77 182.88,168.72 182.85,168.67 182.83,168.62 182.81,168.56 182.8,168.5 180.6,168.5 182.86,170.76 194.16,170.76
+12V_4P on BOTTOM (solid shape): 189.21,167.84 194.92,167.84 195.43,167.33 195.43,164.28 194.98,163.84 187.49,163.84 185.9,162.25 179.87,162.25 178.6,163.52 178.6,166.5 180.6,168.5 182.8,168.5 182.8,168.44 182.81,168.38 182.83,168.33 182.85,168.27 182.88,168.22 182.92,168.18 182.96,168.14 183.01,168.1 183.06,168.07 183.12,168.05 183.18,168.04 183.24,168.04 183.3,168.04 183.35,168.05 183.41,168.07 183.46,168.1 183.51,168.14 183.55,168.18 183.59,168.22 183.62,168.27 183.64,168.33 183.66,168.38 183.67,168.44 183.67,168.5 183.66,168.56 183.64,168.62 183.62,168.67 183.59,168.72 183.55,168.77 183.51,168.81 183.46,168.84 183.41,168.87 183.35,168.89 183.3,168.9 183.24,168.9 183.18,168.9 183.12,168.89 183.06,168.87 183.01,168.84 182.96,168.81 182.92,168.77 182.88,168.72 182.85,168.67 182.83,168.62 182.81,168.56 182.8,168.5 180.6,168.5 181.59,169.49 181.65,169.49 182.86,170.69 186.35,170.69
+12V_4P on PWR (solid shape): 195.56,169.38 195.56,163.94 195.39,163.77 187.45,163.77 186.92,163.24 186.92,162.54 186.75,162.38 179.91,162.38 178.41,163.88 178.41,166.33 180.55,168.47 182.83,168.47 182.83,168.41 182.84,168.36 182.86,168.31 182.89,168.26 182.92,168.21 182.96,168.17 183.01,168.13 183.06,168.1 183.11,168.08 183.17,168.07 183.22,168.06 183.28,168.07 183.33,168.08 183.39,168.09 183.44,168.12 183.49,168.15 183.53,168.19 183.57,168.23 183.6,168.28 183.62,168.33 183.63,168.39 183.64,168.44 183.64,168.5 183.63,168.56 183.62,168.61 183.6,168.66 183.57,168.71 183.53,168.75 183.49,168.79 183.44,168.82 183.39,168.85 183.33,168.87 183.28,168.88 183.22,168.88 183.17,168.87 183.11,168.86 183.06,168.84 183.01,168.81 182.96,168.77 182.92,168.73 182.89,168.69 182.86,168.64 182.84,168.58 182.83,168.53 182.83,168.47 180.55,168.47 182.83,170.76 194.18,170.76
+V1P0A on TOP (solid shape): 57.32,76.21 57.32,74.17 56.11,72.97 56.11,71.06 55.54,70.49 55.54,65.22 55.28,64.97 52.87,64.97 52.36,65.47 52.36,67.38 53.25,68.27 53.25,69.73 54.46,70.94 54.46,71.82 54.2,72.08 53.57,72.08 53.38,72.27 53.38,76.21 53.76,76.59 56.93,76.59
+V1P0A on TOP (solid shape): 64.67,115.54 64.67,114.85 64.64,114.83 63.3,114.83 63.09,114.62 63.08,114.62 62.94,114.52 62.85,114.38 62.84,114.37 62.79,114.32 62.79,114.17 62.54,113.91 62.21,113.91 62.07,114.05 62.07,114.71 62.21,114.85 62.21,115.31 62.54,115.64 64.57,115.64
+V1P0A on TOP (solid shape): 64.67,113.4 64.67,111.91 64.39,111.63 63.53,111.63 63.22,111.93 63.22,112.31 63.27,112.36 63.29,112.36 63.63,112.6 63.62,113.01 63.61,113.05 63.63,113.08 63.97,113.42 64.65,113.42
+V1P0A on TOP (solid shape): outline of 168 points within 29.36,30.83 42.65,39.19
+V1P0A on BOTTOM (solid shape): 52.07,89.42 52.07,87.01 51.99,86.93 50.62,86.93 50.43,87.12 50.42,87.13 50.41,87.15 50.41,87.35 50.66,87.6 50.69,87.61 50.94,87.68 51.1,87.89 51.12,87.96 51.12,88.02 51.12,89.74 51.22,89.84 51.24,89.85 51.25,89.85 51.64,89.85
+V1P0A on BOTTOM (solid shape): 39.6,35.18 40.87,35.18 41.06,34.99 41.06,32.64 39.28,30.87 31.47,30.87 31.09,31.25 31.09,33.98 32.26,35.15 36.21,35.15 36.21,35.09 36.22,35.03 36.24,34.98 36.26,34.92 36.29,34.87 36.33,34.83 36.37,34.79 36.42,34.75 36.47,34.72 36.53,34.7 36.59,34.69 36.65,34.69 36.71,34.69 36.76,34.7 36.82,34.72 36.87,34.75 36.92,34.79 36.96,34.83 37,34.87 37.03,34.92 37.05,34.98 37.07,35.03 37.08,35.09 37.08,35.15 37.07,35.21 37.05,35.27 37.03,35.32 37,35.37 36.96,35.42 36.92,35.46 36.87,35.49 36.82,35.52 36.76,35.54 36.71,35.55 36.65,35.55 36.59,35.55 36.53,35.54 36.47,35.52 36.42,35.49 36.37,35.46 36.33,35.42 36.29,35.37 36.26,35.32 36.24,35.27 36.22,35.21 36.21,35.15 32.26,35.15 33.06,35.95 38.84,35.95
+V1P0A on BOTTOM (solid shape): 48.75,91.97 48.75,91.09 48.75,91.09 48.75,89.19 48.78,89.15 48.85,89.11 48.84,89.03 48.77,88.88 48.77,88.72 48.79,88.65 48.82,88.59 48.89,88.49 48.99,88.42 49.18,88.38 49.37,88.44 49.43,88.47 49.53,88.6 49.57,88.76 49.57,88.86 49.57,88.88 49.58,88.9 49.76,89.08 49.78,89.09 49.8,89.1 50.11,89.1 50.26,88.95 50.26,87.74 50.26,87.73 50.24,87.71 50.15,87.61 50.12,87.61 50.1,87.61 49.72,87.58 49.54,87.23 49.54,87.19 49.55,87.14 49.53,87.06 49.45,87.02 47.76,87.02 46.62,88.16 46.62,90.07 46.81,90.26 46.82,90.26 46.94,90.38 47.96,90.38 48.17,90.6 48.17,92.03 48.32,92.19 48.54,92.19
+V1P0A on BOTTOM (solid shape): 46.37,90.57 46.37,88.46 46.32,88.37 46.22,88.36 45.71,87.9 46.4,87.82 46.47,87.87 46.56,87.84 47.64,86.76 47.95,86.76 48.04,86.72 48.05,86.62 48.02,86.39 48.13,86.19 48.63,86.15 48.74,86.64 48.76,86.72 48.84,86.76 49.5,86.76 49.59,86.72 49.59,86.62 49.94,86.08 50.29,86.62 50.3,86.72 50.39,86.76 50.94,86.76 51.07,86.64 51.07,85.75 50.94,85.62 47.22,85.62 47.22,85.62 45.35,85.62 44.72,86.26 44.72,89.48 45.33,90.09 45.33,90.11 45.43,90.25 45.46,90.42 45.47,90.44 45.73,90.7 46.24,90.7
+V1P0A on PWR (solid shape): outline of 6467 points within 15.39,30.6 68.65,108.6
+V1P0A_VCCAMPHYPLL on TOP (solid shape): outline of 127 points within 58.35,69.67 66.08,79.63
+V1P0A_VCCAPLL on TOP (solid shape): 45.46,98.19 45.5,98.19 45.88,98.19 45.97,98.1 45.97,97.97 45.73,97.73 45.66,97.7 45.59,97.73 45.54,97.77 45.47,97.8 45.15,97.79 44.95,97.53 44.95,97.52 44.92,97.49 44.85,97.49 44.84,97.5 44.71,97.53 44.58,97.5 44.57,97.49 44.34,97.49 44.26,97.41 43.93,97.41 43.81,97.51 43.81,97.8 43.84,97.83 43.86,97.88 43.94,97.95 44.38,97.95 44.62,98.19 45.29,98.19
+V1P0A_VCCF24_1P0 on TOP (solid shape): 60,108.73 60,105.61 59.72,105.33 58.9,105.33 57.18,107.05 57.18,108.83 57.28,108.93 59.79,108.93
+V1P0A_VCCST on TOP (solid shape): 71.21,115 71.21,114.43 70.78,114 68.5,114 68.19,114.32 67.23,114.32 66.73,114.83 65.99,114.83 65.96,114.85 65.96,115.59 66.04,115.66 70.55,115.66
+V1P0A_VCCST on TOP (solid shape): 66.66,113.42 66.68,113.41 66.71,113.38 66.71,113.36 66.7,113.34 66.7,112.46 67.06,112.11 67.06,111.42 66.76,111.13 66.28,111.13 66.1,111.31 66.1,111.77 65.94,111.93 65.43,111.93 65.32,112.04 65.32,112.45 65.48,112.62 65.79,112.62 65.94,112.77 65.94,113.37 65.95,113.4 65.99,113.42
+V1P0A_VCCST on BOTTOM (solid shape): 68.05,115.49 68.05,114.18 65.82,111.96 65.34,111.96 65.15,112.15 65.15,112.77 66.5,114.12 66.5,115.56 66.68,115.74 67.79,115.74
+VCC on TOP (solid shape): 123.43,18.1 123.94,18.1 123.94,18.1 125.26,18.1 125.64,17.72 125.64,16.35 125.39,16.1 123.7,16.1 123.39,16.4 122.1,16.4 121.83,16.67 121.83,17.21 122.34,17.72 122.34,18.04 122.4,18.1 123.43,18.1
+VCC on TOP (solid shape): 91.72,177.39 90.12,177.39 89.71,176.98 89.71,172.67 89.45,172.41 88.24,172.41 87.94,172.71 87.94,177.39 88.65,178.1 91.72,178.1
+VCC on TOP (solid shape): 110.72,23.95 110.72,15.82 109.96,15.06 106.78,15.06 105.8,16.04 105.8,19.82 108.8,19.82 108.8,19.76 108.8,19.7 108.82,19.64 108.84,19.59 108.87,19.54 108.91,19.49 108.96,19.45 109,19.41 109.06,19.39 109.11,19.37 109.17,19.36 109.23,19.35 109.29,19.36 109.35,19.37 109.4,19.39 109.43,19.4 109.87,19.4 109.9,19.39 109.95,19.38 110.01,19.37 110.06,19.37 110.11,19.38 110.16,19.4 110.21,19.42 110.26,19.45 110.3,19.49 110.33,19.53 110.36,19.57 110.38,19.62 110.39,19.67 110.4,19.73 110.4,19.84 110.39,19.9 110.38,19.95 110.36,20 110.33,20.04 110.3,20.08 110.26,20.12 110.21,20.15 110.16,20.17 110.11,20.19 110.06,20.2 110.01,20.2 109.95,20.19 109.9,20.18 109.87,20.17 109.43,20.17 109.4,20.18 109.35,20.2 109.29,20.21 109.23,20.22 109.17,20.21 109.11,20.2 109.06,20.18 109,20.16 108.96,20.12 108.91,20.08 108.87,20.04 108.84,19.99 108.82,19.93 108.8,19.87 108.8,19.82 105.8,19.82 105.8,20.04 105.77,20.07 105.77,24.14 106.21,24.58 110.08,24.58
+VCC on TOP (solid shape): outline of 225 points within 0.55,0.51 50.46,170.66
+VCC on TOP (solid shape): outline of 243 points within 14.45,1.98 56.93,17.34
+VCC on BOTTOM (solid shape): 35.66,8.32 35.66,4.01 35.09,3.43 26.01,3.43 24.3,5.15 23.6,5.15 22.07,3.63 17.95,3.63 16.49,5.09 14.9,5.09 14.45,5.53 14.45,6.48 15.53,7.56 16.42,7.56 17.69,6.29 21.37,6.29 23.28,8.2 25.57,8.2 26.65,7.12 31.15,7.12 32.74,8.71 35.28,8.71
+VCC on PWR: outline of 463 points within 0.51,0.51 199.49,186.63
+VCC3 on TOP (solid shape): outline of 171 points within 55.47,34.11 58.59,46.87
+VCC3 on TOP (solid shape): outline of 223 points within 13.56,151.12 37.14,158.98
+VCC3 on BOTTOM (solid shape): 35.08,156.1 36.22,156.1 36.23,156.09 36.61,156.09 37.19,155.52 37.19,151.61 36.7,151.12 32.11,151.12 31.85,151.38 31.85,152.24 31.39,152.7 30.61,152.7 30.23,153.08 30.23,154.68 30.71,155.16 31.22,155.16 32.36,156.3 32.36,156.53 32.74,156.91 34.27,156.91
+VCC3 on BOTTOM (solid shape): outline of 269 points within 53.44,45.73 57,55.95
+VCC3 on PWR (solid shape): outline of 569 points within 160.93,4.82 180.52,31.9
+VCC3 on PWR (solid shape): outline of 4045 points within 7.26,60.32 37.14,162.77
+VCCGT on TOP (solid shape): outline of 2533 points within 131.48,106.75 175.11,133.55
+VCCGT on BOTTOM (solid shape): outline of 2018 points within 132.94,106.6 175.11,133.55
+VCCGT_PH1 on TOP (solid shape): 186.47,131.51 186.47,127.7 184.95,127.7 184.7,127.45 184.7,127.07 184.57,126.94 183.68,126.94 182.86,126.12 182.86,119.32 182.41,118.88 179.36,118.88 178.98,119.26 178.98,122.27 179.6,122.89 179.6,123.3 178.98,123.92 178.98,125.16 176.95,127.2 171.93,127.2 170.66,128.47 170.66,132.91 170.73,132.97 185.01,132.97
+VCCGT_PH1 on BOTTOM (solid shape): 186.41,131.39 186.41,128.09 186.03,127.7 185.14,127.7 185.11,127.67 184.41,127.67 182.86,126.12 182.86,120.34 182.82,120.31 182.82,119.29 182.41,118.88 179.36,118.88 178.98,119.26 178.98,125.86 176.38,128.47 173.97,128.47 173.33,129.1 173.33,132.4 173.9,132.97 184.82,132.97
+VCCGT_PH1 on PWR (solid shape): 186.54,131.36 186.54,127.86 186.38,127.7 184.48,127.7 182.86,126.08 182.86,119.04 182.63,118.81 179.14,118.81 178.92,119.04 178.92,122.22 179.6,122.9 179.6,123.28 178.92,123.97 178.92,125.19 176.92,127.2 171.96,127.2 170.66,128.5 170.66,132.94 170.76,133.04 184.86,133.04
+VCCGT_PH2 on TOP (solid shape): 187.94,115.26 187.94,106.05 187.87,105.99 186.73,105.99 185.97,105.23 185.27,105.23 185.01,104.97 185.01,103.96 184.95,103.89 171.04,103.89 171.04,108.59 171.52,109.07 174.19,109.07 178.09,112.97 178.6,112.97 179.17,113.54 179.17,114.75 178.92,115 178.92,117.23 179.74,118.05 185.14,118.05
+VCCGT_PH2 on BOTTOM (solid shape): 187.87,115.39 187.87,106.24 187.62,105.99 186.03,105.99 185.01,104.97 185.01,104.15 184.76,103.89 171.3,103.89 171.04,104.15 171.04,108.59 171.49,109.04 174.16,109.04 178.92,113.8 178.92,117.29 179.68,118.05 185.2,118.05
+VCCGT_PH2 on PWR (solid shape): 187.94,115.35 187.94,106.22 187.7,105.99 186,105.99 185.01,105 185.01,103.86 184.98,103.83 171.09,103.83 171.06,103.84 171.04,103.88 171.04,108.62 171.46,109.04 174.12,109.04 178.06,112.97 178.54,112.97 179.22,113.66 179.22,114.76 178.92,115.07 178.92,117.83 179.14,118.05 185.24,118.05
+VCCIO on TOP (solid shape): 78.13,123.97 78.13,121.4 78.03,121.3 77.19,121.3 76.94,121.05 76.94,120.9 77.01,120.82 77.01,120.57 76.94,120.49 76.94,117.44 77.88,116.5 77.88,112.13 77.47,111.73 75.54,111.73 75.03,112.24 75.03,115.48 74.3,116.21 74.3,117.11 73.99,117.42 73.99,121.05 74.37,121.43 74.37,124.07 74.6,124.3 77.8,124.3
+VCCIO on TOP (solid shape): outline of 286 points within 110.82,109.09 115.95,120.9
+VCCIO on BOTTOM (solid shape): outline of 258 points within 75.36,104.72 127.58,114.94
+VCCPFUSE_3P3 on TOP (solid shape): outline of 134 points within 34.84,98.45 40.55,111.58
+VCCPGPPD on TOP (solid shape): 39.16,79.15 39.25,79.1 39.25,79 39.31,78.55 39.76,78.48 39.91,78.48 39.94,78.45 39.94,78.29 38.93,77.28 38.93,73.16 38.94,73.15 38.94,71.98 38.76,71.8 38.02,71.8 37.74,72.08 37.74,77.16 38.67,78.08 38.67,78.46 38.72,78.51 38.72,78.76 38.73,78.85 38.72,78.94 38.72,79.02 38.84,79.15
+VDD1.0 on TOP (solid shape): 65.44,161.11 65.44,160.72 65.06,160.34 65.06,159.39 64.87,159.2 63.09,159.2 62.9,159.39 62.9,160.09 63.16,160.34 64.05,160.34 64.94,161.23 65.32,161.23
+VDD1.0 on BOTTOM (solid shape): 64.62,165.27 64.62,161.99 65.44,161.17 65.44,160.72 64.13,159.41 59.65,159.41 59.35,159.71 59.35,160.22 60.08,160.94 63.55,160.94 63.55,160.89 63.56,160.83 63.58,160.77 63.6,160.72 63.63,160.66 63.67,160.62 63.71,160.58 63.76,160.54 63.81,160.52 63.87,160.5 63.92,160.49 63.98,160.48 64.04,160.49 64.1,160.5 64.16,160.52 64.21,160.54 64.26,160.58 64.3,160.62 64.34,160.66 64.37,160.72 64.39,160.77 64.41,160.83 64.41,160.89 64.41,160.94 64.41,161 64.39,161.06 64.37,161.11 64.34,161.16 64.3,161.21 64.26,161.25 64.21,161.28 64.16,161.31 64.1,161.33 64.04,161.34 63.98,161.35 63.92,161.34 63.87,161.33 63.81,161.31 63.76,161.28 63.71,161.25 63.67,161.21 63.63,161.16 63.6,161.11 63.58,161.06 63.56,161 63.55,160.94 60.08,160.94 61.89,162.76 61.89,165.05 60.76,166.19 56.72,166.19 56.41,166.49 56.41,168.29 56.54,168.42 60.76,168.42 60.99,168.65 61.24,168.65
+VDD33 on TOP (solid shape): 62.78,158.69 62.78,156.91 62.65,156.79 61.37,156.79 60.05,158.11 60.05,158.76 60.3,159.01 62.46,159.01
+VDD33 on TOP (solid shape): 54.97,174.38 54.97,169.74 54.84,169.61 53,169.61 52.74,169.87 52.74,174.44 53,174.69 54.65,174.69
+VDD33 on BOTTOM (solid shape): outline of 217 points within 53.42,156.98 64.24,171.42
+VIN_CPU on TOP (solid shape): 85.76,135.13 87.67,135.13 87.92,134.88 87.92,133.42 87.8,133.29 86.72,133.29 86.08,133.93 85.45,133.93 83.35,136.02 83.35,136.66 83.48,136.78 84.11,136.78
+VIN_CPU on TOP (solid shape): outline of 1191 points within 106.91,101.99 197.18,178.06
+VIN_CPU on BOTTOM (solid shape): outline of 172 points within 190.6,101.99 196,120.72
+VIN_CPU on BOTTOM (solid shape): outline of 210 points within 109.89,170.19 135.42,178.06
+VIN_CPU on BOTTOM (solid shape): outline of 411 points within 176.7,123.32 195.87,163.33
+VIN_CPU on PWR (solid shape): outline of 1135 points within 108.94,101.92 197.21,178.25
AVDDREG1 on TOP (solid shape): 61.21,161.28 61.21,159.38 61.04,159.2 60.4,159.2 60.17,159.43 60.17,160.88 60.5,161.21 60.5,161.64 60.58,161.71 60.78,161.71
GND on TOP (solid shape): 27.6,176.15 27.6,175.33 27.47,175.2 25.12,175.2 24.97,175.35 24.97,176.19 25.12,176.35 27.41,176.35
GND on TOP (solid shape): 37.64,172.1 37.64,171.33 37.33,171.01 35.24,171.01 34.93,171.33 34.93,172.18 35.23,172.48 37.26,172.48
GND on TOP (solid shape): 51.35,34.68 51.35,32.9 51.03,32.58 50.14,32.58 48.68,34.04 48.68,34.87 49,35.18 50.84,35.18
