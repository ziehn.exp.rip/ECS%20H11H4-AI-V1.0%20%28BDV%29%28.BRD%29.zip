# Allegro board ECS H11H4-AI-V1.0-OK.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VDDQ_PWRGD: length 10.9
  TOP w0.203: U32.8 133.39,29.35 133.6,29.56 133.6,29.72
  TOP w0.254: 133.6,29.72 133.6,29.88 135.27,31.54 v1(138.15,31.54) 138.94,32.33 Q46.G R469.1
VSS_SA_IO_SENSE: length 38.9
  TOP w0.102: CPU.AE4 106.73,109.62 106.73,109.01 106.52,108.8 104.07,108.8 104.04,108.77 103.44,108.77 101.55,110.66 93.19,110.66 89.22,106.69 v2(87.86,106.69) ; v2(74.98,109.8) 75.24,109.54 SP15.2
  BOTTOM w0.102: v2(74.98,109.8) v3(74.98,108.81) 74.98,108.11 75.9,107.19 87.35,107.19 v2(87.86,106.69)
1P0A_EN: length 65.7
  TOP w0.102: Q84.3 17.14,34.63 17.76,35.25 R619.2 17.85,35.79 18.14,35.5 18.14,35.22 R621.1 C596.2 20.12,33.22 v2(20.5,32.84) ; v2(49.23,29.33) 49.01,29.12 U31.6
  BOTTOM w0.102: v2(49.23,29.33) 49.43,29.13 49.43,28.47 50.09,27.81 53.65,27.81 54.2,27.25 54.2,25.72 52.71,24.22 41.91,24.22 41.61,24.53 34.24,24.53 33.55,25.22 31.47,25.22 26.77,20.52 21.06,20.52 19.53,22.04 19.53,32.32 20.05,32.84 v2(20.5,32.84)
662_P3: length 3.3
  TOP w0.254: C115.1 v3(16.55,178.89) 16.55,179.2 16.96,179.61 CODEC.3
662_P4: length 3.7
  TOP w0.102: R136.1 v3(18.07,178.06) 17.46,178.67 CODEC.4
662_P9: length 8.2
  TOP w0.102: CODEC.9 19.96,179.73 21.31,178.38 C112.1 21.31,176.98 20.8,176.47 20.8,175.51 v3(20.26,174.96) 19.98,174.68 RJ1.2
+ATX_3VSB: length 588.6
  TOP w0.203: PCH1.BA24 40.17,88.84 v4(40.17,88.91)
  TOP w0.254: v2(177.84,9.78) R575.2 R576.2 R577.2 ; 17.25,70.81 17.88,71.44 v7(18.64,71.44) ; v2(24.69,68.22) 25.06,68.59 R403.2 ; v2(191.49,16.64) R545.2 190.38,18.74 R542.2 ; v2(26,67.44) 26.26,67.71 26.26,68.98 28.11,70.82 29.01,70.82 29.95,71.76 29.95,73.03 30.94,74.02 32.16,74.02 C367.1 33.22,73.99 33.22,74.21 v2(33.76,74.75) ; R385.2 23.22,72.71 23.72,72.21 23.72,70.91 23.18,70.36 R402.2 R415.2 23.12,69.18 22.54,68.6 v2(22.54,68.57) ; C471.1 166.9,31.43 165.44,31.43 165.01,30.99 165.01,29.09 163.23,27.31 163.23,25.56 R518.2 ; v6(49.99,92.73) 50.3,92.73 PCH1.W15 ; R374.2 23.12,79.06 R375.2 22.04,78.11 20.68,76.75 20.68,76.08 18.9,74.3 v7(18.64,74.3) ; R225.1 58.27,155.64 57.74,155.12 52.57,155.12 51.11,156.58 51.11,165.75 47.18,169.68 44.69,169.68 43.16,171.21 40.41,171.21 39.92,171.71 RJ2.3 40.62,173.42 40.62,175.01 v2(40.68,175.08) ; R609.2 R613.2
  TOP w0.305: R337.1 9.4,101.64 9.75,101.29 9.75,100.08 10.21,99.62 10.21,98.82 6.67,95.29 R352.1 ; 168.73,17.25 U35.32 ; 168.51,30.16 168.81,30.16 169.22,29.75 U35.1
  TOP w0.508: v2(185.17,5.91) 187.81,5.91 188.32,5.4 ROM1.8 189.01,3.56 189.36,3.91 R613.2 ; C386.1 24.49,59.51 24.11,59.12 24.11,58.17 ; v2(8.04,70.94) 8.1,70.87 9.87,70.87 11.14,72.14 12.82,72.14 14.16,70.81 17.25,70.81 18.39,69.67 20.86,69.67 21.95,68.57 v2(22.54,68.57) ; v2(167.36,16.39) 167.58,16.61 C542.1 167.75,17.25 168.73,17.25 ; 168.51,30.16 168.16,30.16 C471.1 167.77,30.93 v2(168.5,30.93) ; v2(193.33,33.28) 193.08,33.53 L25.2 ; C345.1 R352.1 8.84,93.06 9.63,92.27 9.63,87.89 ; v2(187.3,12.26) 186.79,12.77 C567.1 185.59,13.69 C557.1
  BOTTOM w0.254: v2(185.17,5.91) 185.17,5.71 v3(182.86,3.4) 180.47,1.02 3.43,1.02 3.16,1.28 ; v2(26,67.44) 25.22,68.22 v2(24.69,68.22) ; v2(40.68,175.08) 39.98,175.77 38.34,175.77 37.13,174.57 32.47,174.57 31.81,175.23 28.67,175.23 27.89,174.45 25.1,174.45 22.84,176.72 22.84,178.43 20.29,180.98 14.02,180.98 13.18,180.15 13.18,177.09 14.82,175.46 14.82,173.89 15.93,172.79 15.93,168.58 14.31,166.96 12.84,166.96 10.01,164.13 10.01,162.56 1.78,154.33 1.78,79.74 4.03,77.48 5.41,76.11 5.41,75.23 4.83,74.65 3.82,74.65 3.15,73.98 3.15,72.59 4.8,70.94 v2(8.04,70.94) ; v7(18.64,74.3) v7(18.64,71.44) ; v6(49.99,92.73) 45.09,92.73 44.65,92.3 44.65,91.15 42.06,88.56 40.51,88.56 v4(40.17,88.91) 39.15,88.91 37.9,87.65 36.37,87.65 33.45,84.73 33.45,75.05 v2(33.76,74.75)
  BOTTOM w0.508: v2(7.82,61.51) 1.14,54.83 1.14,3.3 2.04,2.41 3.16,1.28 ; v2(22.54,68.57) 24.33,68.57 v2(24.69,68.22)
  BOTTOM w0.635: v2(8.74,86.79) 9.75,85.78 v2(9.75,80.78)
  vias: v2(180.7,7.18)
+ATX_3VSB_FB: length 9.2
  TOP w0.102: R352.2 v1(5.72,93.95)
  TOP w0.508: U26.7 6.07,86.37 5.12,87.32 5.12,90.27 R356.2 C345.2 R352.2
+ATX_5VSB: length 301.8
  TOP w0.203: R618.1 13.56,34.99 13.06,35.5 13.06,37.28 14.33,38.55 v2(15.72,38.55)
  TOP w0.508: v2(136.56,9.21) 136.69,9.09 C595.1 137.42,9.66 R585.1 R573.1 ; R448.2 9.47,57.35 v2(9.12,56.99) ; v2(107.23,8.24) 107.42,8.24 R590.2 107.16,9.5 107.16,11.37 107.74,11.95 D24.2
  TOP w1.778: 24,26.24 24,33.77 21.18,36.59 21.18,38.17 19.41,39.95 19.41,50.11 v2(17.52,51.99) 15.76,53.75 9.58,53.75 v2(8.56,54.77) 6.01,57.32 6.01,75.11
  BOTTOM w0.203: v2(15.72,38.55) 15.47,38.55 15.13,38.89 15.13,43.67 16.41,44.95 16.41,50.88 v2(17.52,51.99)
  BOTTOM w0.508: ATX_POWER.10 86.45,4.22 94.73,4.22 98.75,8.24 v2(107.23,8.24) 118.81,8.24 119.22,7.83 130.66,7.83 131.36,8.53 135.88,8.53 v2(136.56,9.21) ; v2(8.56,54.77) 8.56,56.43 v2(9.12,56.99)
  BOTTOM w0.762: v5(6.07,160.22) 6.99,161.14 7.69,161.14 9.31,162.76 9.31,164.41 12.52,167.61 14.06,167.61 15.28,168.83 15.28,172.54 12.55,175.27 12.55,180.41 13.75,181.62 20.55,181.62 23.47,178.69 23.47,176.98 25.36,175.09 27.63,175.09 28.4,175.86 32.33,175.86 33,175.2 36.87,175.2 38.2,176.54 43.57,176.54 v8(45.31,178.28)
  BOTTOM w1.016: v5(4.65,75.7) 1.02,79.33 1.02,155.16 v5(6.07,160.22)
  vias: v5(25.76,23.56) v5(27.28,23.56) v8(52.68,25.09) v8(53.38,25.85)
+DDR_VTT: length 11
  TOP w0.203: U32.18 131.05,24.82 C503.2 131.85,24.75 U32.20
  TOP w0.508: C402.1 115.46,54.12 C405.1
  TOP w0.762: C402.1 114.21,52.15 DIMM2.77
  BOTTOM w0.762: DIMM2.77 114.4,51.56 114.4,48.16 DIMM2.221
  vias: v2(131.74,23.37) v2(132.5,23.37) v5(112.31,33.41)
+DIMM_5VDUAL: length 187.9
  TOP w0.102: v2(19.6,10.29) 19.34,10.55 RJ4.3
  TOP w0.203: v2(128.3,9.72) 128.3,11.7 126.91,13.09 126.91,14.23 125.78,15.36 123.27,15.36 122.86,15.77 121.69,15.77 120.31,17.15 120.31,18.48
  TOP w0.381: U29.4 104.06,32.21 104.06,32.87 C456.2 107.16,33.47 109.64,30.99 109.64,29.64 110.21,29.07 110.21,28.42 R502.2 109.64,27.28 116.07,20.85 EC24.1
  TOP w0.508: R557.1 R558.1 v2(101.51,10.74) 101.33,10.56 100.76,10.56 99.73,9.53 R604.1 R603.1 ; R477.2 v2(137.71,32.2)
  BOTTOM w0.102: v2(19.6,10.29) 19.9,10.6 30.51,10.6 35.26,15.34 41.74,15.34 43.08,16.68 55.86,16.68 58.12,14.42 61.21,14.42 63.23,12.4 65.14,12.4 65.91,11.63 66.61,11.63 67.62,10.62 67.62,10.15 69.37,8.39 96.36,8.39 98.08,10.11 100.89,10.11 v2(101.51,10.74)
  BOTTOM w0.203: v2(128.3,9.72) 127.81,10.2 120.7,10.2 120.45,9.95 116.94,9.95 115.92,10.97 106.55,10.97 106.27,10.69 v3(102.36,10.69) 101.56,10.69 v2(101.51,10.74)
  BOTTOM w0.508: v2(137.71,32.2) 137.71,25.66 137.2,25.15 135.74,25.15 133.19,22.6 128.75,22.6 128.11,21.96 121.37,21.96 v2(121.07,21.66)
+DRIVER_POWER: length 171.5
  TOP w0.508: R184.2 131.94,166.82 v2(131.56,167.2) ; R181.2 v2(114.85,165.23) ; v2(149.26,181.43) 149.26,179.2 164.01,164.46 176.81,164.46 v2(176.82,164.47) ; v2(188.82,118.31) 188.82,119.45 188.7,119.58 ; R265.2 v2(189.52,134.18) ; R346.1 R338.1 v2(193.62,100.72) 193.43,100.53 R345.2
  BOTTOM w0.508: v2(114.85,165.23) 114.85,166.07 116.1,167.33 131.43,167.33 v2(131.56,167.2) 131.69,167.33 134.26,167.33 134.72,167.79 139.27,167.79 139.73,167.33 142.72,167.33 145.83,170.44 145.83,178 v2(149.26,181.43) ; v2(176.82,164.47) 176.19,163.84 176.19,158.76 177.33,157.61 185.33,157.61 189.4,153.55 189.4,145.67 191.81,143.26 191.81,137.36 189.52,135.07 v2(189.52,134.18) 190.63,133.07 190.63,125.77 v3(191.11,125.29) 191.76,124.64 191.76,121.37 188.82,118.43 v2(188.82,118.31) 188.82,117.54 189.52,116.85 189.52,104.84 193.62,100.74 v2(193.62,100.72)
+DVI_VGA_VCC: length 43.3
  BOTTOM w0.508: v2(129.72,197.45) 132.49,200.22 v3(138.02,200.22) 138.74,200.22 140.77,198.19 161.84,198.19 167.42,203.78 v2(167.42,205.11)
+DVI_VGA_VCC_F:
  vias: v1(125.81,188.11)
+DVI_VGA_VCC_G: length 2.3
  TOP w0.102: R91.1 v1(126.04,184.22)
  TOP w0.254: R91.1 127.04,184.25 Q9.G
+LDOVDD: length 4.9
  TOP w0.254: CODEC.29 19.46,189.33 19.47,189.34 19.47,190.26 18.96,190.76
  TOP w0.508: C32.1 18.77,193.2 18.77,190.95 18.96,190.76
  vias: v2(5.94,164.34) v2(6.77,164.34) v2(17.18,191.71) v2(17.95,191.71) v3(12.12,190.82)
+RTCVCC: length 137.3
  TOP w0.203: PCH1.BA22 39.84,90.09 v4(40.07,90.32)
  TOP w0.254: v2(10.63,103.7) 10.52,103.82 D15.3 ; v2(11.23,55.58) 11.43,55.38 14.37,55.38 15.77,56.77 17.37,56.77 22.33,51.81 22.33,45.06 22.78,44.61 24.97,44.61 CLR_CMOS.1 ; v2(26.34,82.92) 26.34,82.95 26.37,82.97 26.37,85.77 27.66,87.06 30.65,87.06 31.69,88.11 R360.1 R358.1
  TOP w0.381: v2(26.7,77.35) 26.8,77.25 C363.1 26.8,75.48 C364.1 ; v2(26.34,82.92) 23.88,80.46 21.87,80.46 19.41,78 19.41,76.71 18.73,76.04 v2(14.75,76.04)
  BOTTOM w0.254: v2(10.63,103.7) 10.63,86.29 10.33,85.98 10.33,80.92 12.69,78.56 12.69,77.82 13.03,77.48 13.77,77.48 14.75,76.5 v2(14.75,76.04) 14.99,75.8 14.99,69.53 14.22,68.77 14.22,66.77 13.69,66.24 13.69,61.66 11.79,59.76 11.79,56.14 v2(11.23,55.58) ; v4(40.07,90.32) 39.64,90.75 38.74,90.75 37.7,89.7 36.62,89.7 30.79,83.87 29.22,83.87 27.47,82.12 27.47,79.86 27.2,79.6 27.2,77.85 v2(26.7,77.35)
  BOTTOM w0.381: v2(26.7,77.35) 26.25,77.35 25.32,78.28 25.32,79.44 26.34,80.46 v2(26.34,82.92)
+SPI_3P3V: length 28.2
  TOP w0.508: D19.3 29.28,52.36 R457.1 29.44,54.23 C407.1 29.5,55.6 C399.1 ; C399.1 28.77,56.77 R449.1 ; C399.1 SPIROM1.8 33.1,55.82 33.61,56.33 v2(33.61,59.58) ; R438.2 45.47,59.85 45,60.33 36.93,60.33 v2(36.37,60.89)
  BOTTOM w0.508: v2(33.61,59.58) 34.91,60.89 v3(35.23,60.89) v2(36.37,60.89)
+USB3VCC2_1: length 17.3
  TOP w0.457: C491.1 v2(11.02,27.06) ; U30.5 v2(11.02,29.28)
  BOTTOM w0.457: v2(11.02,29.28) v2(11.02,27.06) 10.33,26.36 10.33,15.12 v2(11.02,14.42)
+USB3VCC_C1: length 84.3
  TOP w0.457: v2(87.22,192.47) U8.5
  TOP w0.508: C44.1 v2(84.62,192.35)
  TOP w1.016: v5(125.58,185.29) 100.4,185.29 EC3.1
  BOTTOM w1.016: v5(125.58,185.29) 126.67,186.38 141.07,186.38 150.22,195.52 166.54,195.52 173.71,202.7
  vias: v2(94.08,200.28) v2(94.15,199.33) v2(96.43,195.9) v2(96.56,197.05) v2(97.57,189.3) v2(97.57,188.47) v2(98.4,189.3) v2(98.4,188.54) v2(99.42,190.32) v2(99.49,191.13) v2(174.92,201.43) v2(174.92,200.54) v2(180.57,204.16)
+USBVCC0: length 28.3
  TOP w0.508: U13.5 v2(58.99,179.8) ; C88.1 v2(59.28,182.06)
  BOTTOM w0.508: v2(81.26,185.36) 81.26,184.22 80.38,183.34 61.71,183.34 60.43,182.06 v2(59.28,182.06) 58.99,181.77 v2(58.99,179.8)
  vias: v2(81.26,186.25) v2(82.02,185.36) v2(82.14,186.25) v2(86.72,173.88) v2(86.72,173.09) v2(86.72,172.28) v2(97.79,178.15) v2(98.35,178.76) v2(98.97,179.39) v2(99.48,179.96)
+USBVCC2: length 272.8
  TOP w0.203: v2(12.8,7.24) 12.8,1.66 13.85,0.61 195.02,0.61 198.16,3.75 198.16,25.47 196.32,27.31 R509.1
  TOP w0.508: v2(10.92,37.99) 11.02,37.89 U28.5
  BOTTOM w0.203: F_USB.1 4.09,45.65 4.09,11.19 6.39,8.9 11.91,8.9 12.8,8.01 v2(12.8,7.24)
  BOTTOM w0.508: v2(10.92,37.99) 10.26,38.65 10.26,41.39 11.02,42.16 11.02,43.78 v2(10.87,43.93)
+V_3P3_LAN:
  vias: v1(49.12,173.93)
+V_3P3_LAN_G1: length 3.8
  TOP w0.102: C121.1 v1(50.33,176)
  TOP w0.508: C121.1 50.8,175.04 50.96,174.88 Q15.G 51.66,176.25 R138.1
+VCORE: length 184.9
  TOP w0.254: SP8.1 174.5,141.87 L21.2 ; v2(189.21,37.92) 187.68,37.92 187.3,37.53 183.17,37.53 v2(183.11,37.6) ; L17.2 129.26,152.87 SP5.1 ; R475.1 193.02,32.71 v2(193.33,32.39) ; L18.2 146.09,152.94 SP6.1 ; R124.2 157.73,178 v2(157.53,178.2)
  BOTTOM w0.254: v2(149.9,148.47) 151.32,149.89 151.32,157.82 154.18,160.67 154.18,175.67 156.71,178.2 v2(157.53,178.2) ; 131.88,106.24 134.07,106.24 134.35,106.52 134.35,110.79 135.13,111.58 140.41,111.58 141.04,112.21 141.04,112.54 141.56,113.06 142.17,113.06 143.54,114.42 157.03,114.42 175.43,96.02 179.81,96.02 183.55,92.27 185.08,92.27 188.06,89.29 188.06,64.15 190.87,61.35 190.87,60.14 186.78,56.05 186.78,53.83 182.88,49.93 182.88,37.83 v2(183.11,37.6) ; v2(189.21,37.92) 189.33,37.92 192,35.25 192,33.72 v2(193.33,32.39)
  vias: v2(116.75,145.61) v2(117.96,146.82) v2(117.96,144.28) v2(119.23,145.55) v2(119.6,107.43) v2(120.54,107.43) v2(121.45,107.43) v2(122.39,107.43) v2(123.38,107.43) v2(123.8,145.42) v2(124.35,107.43) v2(124.63,141.29) v2(124.63,140.15) v2(125.07,146.75) v2(125.07,144.21) v2(125.22,107.46) v2(125.39,153.61) v2(125.39,152.15) v2(125.39,150.63) v2(126.14,107.43) v2(126.34,145.55) v2(127.04,152.34) v2(127.1,153.61) v2(127.17,107.38) v2(127.67,151.14) v2(128.31,141.29) v2(128.31,140.21) v2(129.13,150.63) v2(130.98,145.48) v2(132.25,146.75) v2(132.25,144.21) v2(132.25,140.79) v2(133.52,145.55) v2(135.93,141.36) v2(135.93,140.15) v2(138.15,145.48) v2(139.42,146.82) v2(139.42,144.21) v2(140.69,145.48) v2(141.2,140.85) v2(144.44,151.26) v2(145.77,150.56) v2(147.3,153.49) v2(147.36,151.14) v2(147.74,152.28) v2(165.33,143.33) v2(166.6,141.93) v2(166.66,144.53) v2(167.93,143.26) v2(171.04,139.32) v2(172.06,140.09) v2(173.65,143.13) v2(174.66,142.94) v5(124.18,138.63) v5(127.23,135.43) v5(128.88,138.63) v5(131.65,135.71) v5(133.45,138.56) v5(134.16,132.94) v5(136.67,135.71) v5(138.21,138.56) v5(140.06,132.66) v5(141.64,136.15) v5(142.6,138.69) v5(146.22,140.72) v5(146.34,144.72) v5(146.41,148.15) v5(150.34,144.66) v7(121.49,119.14) v7(121.49,118.15) v7(121.49,116.99) v7(121.49,116.1) v7(121.49,115.13) v7(121.49,114.27) v7(121.49,113.23) v7(121.49,112.36) v7(121.49,111.42) v7(121.49,110.48) v7(121.49,109.44) v7(121.48,108.61) v7(124.1,122.42) v7(125.02,122.4) v7(125.02,121.51) v7(125.78,117.29) v7(125.81,116.55) v7(125.78,115.87) v7(125.81,115.05) v7(125.81,114.19) v7(125.81,113.2) v7(125.81,112.13) v7(125.81,111.17) v7(125.81,110.2) v7(125.81,109.24) v7(125.81,108.45) v7(125.93,124.22) v7(125.93,122.42) v7(126.85,124.22) v7(126.85,122.4) v7(126.85,121.51) v7(127.79,129.74) v7(127.79,127.91) v7(127.76,126.05) v7(127.76,125.19) v7(127.76,124.25) v7(127.76,123.36) v7(127.76,122.42) v7(128.65,132.61) v7(128.68,131.56) v7(128.68,129.74) v7(128.68,127.91) v7(128.68,126.99) v7(128.68,126.05) v7(128.7,125.16) v7(128.68,124.22) v7(128.7,123.34) v7(128.65,122.42) v7(128.67,121.51) v7(129.59,132.61) v7(129.59,131.56) v7(129.57,129.74) v7(129.59,127.91) v7(129.59,126.05) v7(129.59,124.22) v7(129.59,122.4) v7(130.51,132.61) v7(130.51,131.54) v7(130.51,130.63) v7(130.51,129.74) v7(130.53,128.82) v7(130.51,127.88) v7(130.51,127.02) v7(130.51,126.08) v7(130.51,125.16) v7(130.51,124.22) v7(130.53,123.34) v7(130.51,122.4) v7(130.5,121.51) v7(134.52,130.73) v7(134.52,129.74) v7(134.54,128.82) v7(134.52,127.91) v7(134.54,126.99) v7(134.54,126.08) v7(134.52,125.16) v7(134.54,124.25) v7(135.43,129.74) v7(135.46,130.78) v7(135.46,127.91) v7(135.46,126.08) v7(136.35,130.78) v7(136.35,128.82) v7(136.35,126.99) v7(136.36,129.74) v7(136.36,127.91) v7(136.37,126.08) v7(137.29,130.78) v7(137.29,129.74) v7(137.29,127.91) v7(138.2,130.75) v7(138.19,129.74) v7(138.18,128.82) v7(138.19,127.91) v7(139.12,130.75) v7(139.11,129.71)
+VCORE_PH1: length 5.5
  TOP w0.254: SP4.1 146.09,157.71 144.95,158.86 L18.1 ; C167.1 138.09,164.85 137.7,165.24 U17.7
  TOP w0.508: 138.09,163.2 C167.1
  vias: v2(139.42,157.3) v2(139.42,155.45) v2(140.63,155.2) v2(140.69,163.45) v2(140.69,161.61) v2(140.69,159.9) v2(140.69,152.98) v2(140.69,151.01) v2(140.75,157.99) v2(141.9,156.09) v2(142.47,162.95) v2(142.6,158.88) v2(143.17,160.28) v2(143.17,157.42) v2(143.55,156.09) v2(144.56,157.1) v2(144.69,163.01) v2(144.82,160.6) v2(145.96,159.45)
+VCORE_PH1_R: length 1.8
  TOP w0.508: R229.1 134.15,156.41 133.86,156.69 C199.2
+VCORE_PH2: length 9.3
  TOP w0.254: SP3.1 129.26,157.6 128,158.86 L17.1 ; U16.7 118.27,164.98 118.4,164.85
  TOP w0.508: 118.4,164.85 118.72,164.53 C166.1 119.55,162.03 QCL5.D5
  vias: v2(121.32,157.3) v2(121.32,155.52) v2(123.93,163.39) v2(123.86,157.3) v2(123.86,155.58) v2(123.93,153.93) v2(123.93,152.41) v2(123.93,150.88) v2(123.99,161.49) v2(123.99,159.58) v2(125.51,163.39) v2(125.77,159.07) v2(126.34,157.49) v2(126.28,155.96) v2(126.4,160.41) v2(127.67,157.04) v2(127.86,162.57) v2(128.05,160.53) v2(129.2,159.52)
+VCORE_PH2_R: length 1.7
  TOP w0.508: R228.1 116.05,156.41 115.83,156.18 C200.2
+VCORE_PH3: length 10.1
  TOP w0.254: L21.1 179.4,141.86 SP9.1
  TOP w0.305: U21.7 v2(188.07,141.04)
  TOP w0.508: C228.1 v2(186.54,140.02)
  BOTTOM w0.508: v2(188.07,141.04) 187.55,141.04 v2(186.54,140.02) 183.17,140.02 v2(182.54,139.39)
  vias: v2(175.93,145.99) v2(176.7,148.66) v2(176.7,147.26) v2(177.46,144.34) v2(178.6,148.66) v2(178.6,147.33) v2(179.36,144.4) v2(179.74,145.93) v2(179.74,140.79) v2(179.68,139.39) v2(181.33,144.28) v2(181.52,141.1) v2(182.16,145.93) v2(182.16,142.75) v2(184.25,145.93)
+VCORE_PH3_R: length 2.6
  TOP w0.102: C202.2 v1(178.54,154.63)
  TOP w0.508: 177.65,152.98 177.65,153.99 177.62,154.02 C202.2
+VDIMM: length 287.7
  TOP w0.102: DIMM2.7 174.09,49.2 174.83,48.47 174.83,47.58 174.06,46.81 174.06,41.9 DIMM1.7 ; C437.1 155.14,45.09 155.39,45.34 155.39,46.87 156.11,47.58 156.11,48.52 155.4,49.23 DIMM2.29
  TOP w0.152: DIMM2.51 136.7,49.17 137.38,48.48 137.38,47.49 136.72,46.82 136.72,45.54 136.47,45.28 C435.1
  TOP w0.254: v2(139.68,28.2) R504.2 C492.2 ; v2(189.21,37.15) 189.08,37.03 183.97,37.03 182.96,36.01 v2(180.82,36.01) ; R482.1 v2(193.33,31.63) ; 112.26,98.65 v4(112.22,98.65) ; 112.26,98.65 112.22,98.69 112.22,99.38 112.4,99.56 112.71,99.56 112.71,99.56 113.82,99.56 112.9,98.65 112.26,98.65
  TOP w0.305: v4(126.82,94.52) 126.76,94.58 CPU.AY23 ; CPU.AU15 v4(118.97,98.65)
  TOP w0.356: v4(129.01,96.82) 129.05,96.82 CPU.AW25 ; DIMM2.18 164.74,47.62 165.61,46.76 165.61,45.62 164.73,44.74 C438.1 164.73,40.29 DIMM1.18 ; DIMM1.110 81.46,44.12 C430.1 82.29,44.95 82.29,46.79 81.46,47.63 DIMM2.110 ; DIMM1.51 136.47,42.1 C435.1 ; CPU.AY16 v4(120.36,94.66) ; CPU.AY12 116.7,94.89 v4(116.62,94.81) ; DIMM2.121 72.11,49.58 72.92,48.77 72.92,47.6 72.13,46.81 72.13,44.15 C429.1 72.14,41.9 DIMM1.121 ; DIMM2.40 146.05,47.65 146.91,46.79 146.91,45.34 146.5,44.93 C436.1 146.5,43.41 146.05,42.95 DIMM1.40 ; DIMM1.29 155.14,42.13 C437.1 ; CPU.AU13 v4(118.07,97.73) ; CPU.AV11 115.51,97.27 v4(115.16,96.92) ; CPU.AU23 v4(127.24,98.65) ; DIMM1.99 90.75,41.92 C431.1 90.83,44.22 90.83,46.71 91.62,47.5 91.62,48.62 90.81,49.43 DIMM2.99 ; v4(123.58,98.65) 123.13,98.19 CPU.AU19 ; DIMM2.132 62.76,47.55 63.57,46.74 63.57,45.6 63.25,45.28 C428.1 63.25,43.34 62.76,42.85 DIMM1.132 ; CPU.AV17 v4(121.73,96.82) ; v4(122.21,94.69) 122.19,94.71 CPU.AY18 ; v4(112.24,97.71) CPU.AW10 ; CPU.AT18 v4(121.76,98.65) ; C432.1 96.78,46.33 DIMM2.236 ; CPU.AW14 v4(118.07,95.9) ; v4(125.36,98.65) 124.93,99.08 CPU.AT21 ; v4(124.93,96.64) CPU.AV21
  TOP w0.508: DIMM1.59 129.17,42.6 C434.1 129.17,46.25 DIMM2.204 ; v2(110.34,43.38) 110.5,43.53 R462.1 R461.1 ; DIMM2.67 123.1,53.63 C410.1 ; C438.1 v2(166.6,44.14) ; C409.1 117.75,53.62 117.75,52.01 DIMM2.73 ; DIMM1.204 129.01,36.43 R472.1 ; C422.1 124.02,42.79 DIMM1.67 ; R440.1 C392.1 R454.1 C415.1 189.74,53.06 189.21,52.52 185.84,52.52 182.92,49.6 182.92,38.42 180.82,36.33 v2(180.82,36.01) ; DIMM1.85 102.88,42.04 C433.1 ; C418.1 105.42,46.2 DIMM2.226 ; DIMM1.73 118.31,42.17 C421.1 ; C411.1 127.61,52.79 128.2,52.2 DIMM2.61 ; v2(137.64,44.14) C435.1 ; R321.2 114.47,108.11 114.47,100.21 113.82,99.56 ; C437.1 v2(154.28,44.14) ; C436.1 v2(144.76,44.14) ; DIMM2.59 129.56,52.1 129.56,52.77 129.07,53.27 C412.1
  BOTTOM w0.254: v2(119.29,34.55) 119.93,33.91 138.21,33.91 139.48,32.64 139.48,30.61 138.91,30.04 138.91,28.96 v2(139.68,28.2) ; v2(193.33,31.63) 193.21,31.63 191.49,33.34 191.49,34.87 v2(189.21,37.15)
  BOTTOM w0.508: v2(180.82,36.01) 179.3,34.49 143.55,34.49 v5(142.72,33.66)
  BOTTOM w1.016: v5(122.97,34.74) 139.42,34.74 140.5,33.66 v5(142.72,33.66)
  vias: v2(64.11,44.2) v2(73.06,44.14) v2(82.21,43.82) v2(91.54,44.27) v2(97.7,44.14) v2(110.78,71.13) v2(110.78,70.24) v2(110.78,69.35) v2(115.29,33.47) v2(115.29,31.44) v2(115.29,29.34) v2(116.62,27.44) v2(117.7,29.66) v2(117.77,32.64) v2(118.47,25.53) v2(119.36,29.15) v2(120.31,31.95) v2(120.37,27.5) v2(120.56,30.23) v2(130.9,75.3) v2(130.92,74.49) v2(130.9,69.59) v2(130.9,68.86)
+VGA_VCC: length 24.9
  TOP w0.203: 109.77,197.74 109.2,197.74 109.01,197.56 U4.17
  TOP w0.406: v2(121.51,200.28) 121.51,199.92 121.91,199.52 U2.5 ; v2(115.79,199.93) 116.19,199.52 U1.5
  TOP w0.508: 109.77,197.74 109.94,197.74 110.48,198.28 C8.2 111.64,199.59 C9.2 v2(111.81,200.97) ; v2(125.45,193.13) R33.1 R32.1 ; v2(121.2,198.25) 121.13,198.19 C19.1 ; v2(114.34,198.25) 115.1,197.49 C24.1
  BOTTOM w0.457: 124.75,203.33 124.75,204.55 123.24,206.06 VGA.9
  BOTTOM w0.508: 126.28,198.19 126.28,193.96 v2(125.45,193.13) ; 124.75,200.86 124.75,203.33
  vias: v2(129.54,199.43) v3(118.09,199.79)
-ACTIVE_P: length 8.4
  TOP w0.102: R121.1 R120.2 77.46,179.25 D7.N 76.49,179.84 76.65,180 C91.1 76.65,184.81 USB2_LAN.13
A20GATE: length 4
  TOP w0.102: U35.43 175.64,15.02 175.2,14.58 174.63,14.58 v2(174.47,14.42) 174.12,14.07 R555.1
  BOTTOM w0.102: v3(174.47,15.31) v2(174.47,14.42)
ANTI_POP_L: length 2.6
  TOP w0.254: R111.2 12.8,181.6 v1(13.08,181.88) 13.61,182.41 CODEC.47
ATX_PSON_L: length 477
  TOP w0.102: v2(9.5,70.19) 9.84,70.19 11.29,71.63 12.61,71.63 14.83,69.41 14.83,68.14 15.34,67.63 17.29,67.63 18.45,68.8 20.33,68.8 v2(20.42,68.71) ; v2(68.25,10.28) 68.25,9.24 68.43,9.06 R616.1 ; R153.1 38.74,174.9 v2(38.77,174.92) ; Q63.G 190.03,13.72 192.06,15.75 192.06,18.01 R545.1 190.98,19.09 190.98,19.73 190.4,20.31 189.31,20.31 189.12,20.5 U35.73 181.28,20.5 v2(180.38,21.41) ; v2(80.75,8.96) 78.65,6.86 78.65,4.86 76.72,2.93 C583.1 ; C583.1 76.14,5.54 ATX_POWER.8 ; C583.1 75.27,2.05 66.65,2.05 66.31,2.39 66.31,3.97 65.99,4.29 65.35,4.29 63.92,5.72 59.28,5.72 58.46,4.9 57.76,4.9
  BOTTOM w0.102: v2(20.42,68.71) 20.42,68.2 19.71,67.49 19.71,65.43 20.83,64.31 20.83,62.34 18.16,59.67 18.16,55.44 14.77,52.05 14.77,45.92 13.58,44.73 13.58,36.75 11.74,34.91 11.74,18.97 12.5,18.21 12.5,18.02 12.5,13.13 12.67,12.96 12.86,12.77 14.8,10.83 30.3,10.83 35.07,15.6 41.68,15.6 42.99,16.91 55.95,16.91 58.06,14.8 61.54,14.8 62.94,13.4 64.75,13.4 65.63,12.52 66.14,12.52 68.25,10.41 v2(68.25,10.28) 69.25,9.28 80.43,9.28 v2(80.75,8.96) 81.08,8.62 96.22,8.62 98.91,11.31 116.02,11.31 117.07,10.25 119.62,10.25 119.88,10.51 132.3,10.51 132.66,10.14 134.5,10.14 135.22,10.86 137.03,10.86 138.07,9.82 140.16,9.82 140.49,9.49 142.51,9.49 144.76,7.24 145.33,7.24 146.47,8.39 149.9,8.39 150.74,9.23 167.03,9.23 168,8.25 172.69,8.25 176.31,11.88 176.31,14.61 175.95,14.98 175.95,18.75 178.6,21.41 v2(180.38,21.41) ; v2(9.5,70.19) 9.5,70.49 8.48,71.51 4.74,71.51 3.47,72.78 3.47,73.79 4.01,74.33 4.93,74.33 4.95,74.35 4.96,74.35 5.72,75.1 5.72,76.23 4.25,77.7 3.52,78.43 2.08,79.86 2.08,154.2 10.31,162.43 10.31,164 12.97,166.65 14.44,166.65 16.23,168.45 16.23,172.98 15.13,174.08 15.13,175.58 13.54,177.17 13.54,179.72 14.28,180.46 20.22,180.46 22.33,178.35 22.33,176.47 24.4,174.4 24.4,173.52 24.4,173.52 24.95,172.97 36.81,172.97 v2(38.77,174.92)
ATX_PSON_L_C: length 4
  TOP w0.102: QN7.D v2(60.05,4.9)
  TOP w0.508: QN7.D R612.2
  BOTTOM w0.102: v3(59.21,4.9) v2(60.05,4.9)
ATX_PSON_L_D: length 7.3
  TOP w0.102: v1(40.64,171.77) 40.93,172.07 RJ2.2
  TOP w0.254: Q14.D 41.06,176.41 41.44,176.03 D12.G 41.44,173.55 40.93,173.04 RJ2.2
ATX_PSON_L_R: length 2.4
  TOP w0.102: R153.2 37.79,172.39 v1(38.28,171.9)
  TOP w0.254: R153.2 37.79,174.09 Q14.G
ATX_PWRGD: length 258.4
  TOP w0.102: R528.1 162.86,22.74 158.59,18.47 150.22,18.47 148.58,16.83 148.58,11.45 147.04,9.91 147.04,8.26 146.63,7.85 v2(145.01,7.85) ; ATX_POWER.9 80.63,2.97 C584.1 R614.2 78.98,3.4 78.98,3.98 78.97,3.99 78.97,6.42 81.57,9.02 v2(81.57,9.21) ; v2(18.72,56.54) 19.45,56.54 23.68,52.31 23.68,49.38 24.71,48.35 25.88,48.35 26.01,48.22 26.65,48.22 26.81,48.39 27.79,48.39 27.89,48.29 27.89,41.37 29.11,40.15 29.11,37.55 R466.2
  BOTTOM w0.102: v2(18.72,56.54) 18.39,56.2 18.39,55.35 15,51.95 15,45.82 13.81,44.63 13.81,36.65 11.96,34.81 11.96,19.06 12.73,18.3 12.73,17.92 12.73,13.23 13.09,12.86 13.09,12.86 14.9,11.05 30.2,11.05 34.97,15.82 41.58,15.82 42.89,17.14 56.05,17.14 57.91,15.27 64.28,15.27 65.13,14.42 65.13,13.4 65.71,12.82 66.19,12.82 67.86,11.15 68.9,11.15 70.52,9.53 81.26,9.53 v2(81.57,9.21) 81.93,8.85 96.03,8.85 98.72,11.54 116.14,11.54 117.2,10.48 119.49,10.48 119.75,10.74 132.58,10.74 132.94,10.37 134.4,10.37 135.13,11.09 137.12,11.09 138.14,10.07 140.39,10.07 140.74,9.72 142.62,9.72 144.49,7.85 v2(145.01,7.85)
ATX_PWRGD_R: length 6.3
  TOP w0.102: U35.16 169.09,23.7 168.9,23.52 168.9,23.15 v1(168.55,22.8) 168.49,22.74 C511.1 167.1,22.26 165.34,22.26 R528.2
AUGND: length 69.4
  TOP w0.254: CODEC.26 20.96,189.71 21.5,190.25 21.5,190.54 C46.2 ; CODEC.42 v2(15.78,184.91)
  TOP w0.381: Q7.E2 20.72,197.79 v2(20.8,197.87) ; v2(28.87,202.11) Q5.E2 ; Q2.E2 15.2,201.67 v2(14.83,201.3) ; Q3.E2 v2(20.74,202.11) ; v2(21.5,204.29) 21.77,204.02 Q4.E1 ; v2(13.12,204.22) 13.2,204.14 Q2.E1 ; Q3.E1 17.77,204.08 v2(17.63,204.22) ; Q7.E1 18.28,199.09 v2(18.58,199.4) ; Q4.E2 v2(24.61,202.11) ; Q1.E1 8.79,203.41 8.42,203.78 v2(8.42,204.22) ; v2(25.38,204.16) 25.38,204.11 25.65,203.84 Q5.E1 ; v2(11.91,202.11) Q1.E2 10.88,201.28 R12.2
  TOP w0.508: R29.2 C30.1 v2(7.69,195.05) ; v2(22.84,195.9) 22.84,194.95 C35.2 23.79,195.14 v2(23.79,195.9) ; v2(20.68,195.9) 20.68,195.27 C34.2 21.82,195.27 v2(21.82,195.9) ; R24.2 C26.1 7.75,196.19 v2(7.6,196.03) ; v2(40.42,189.36) 40.42,189.14 D4.3 ; v2(25.5,178.44) R134.1 v2(26.52,177.42) ; C73.2 39.85,186.19 v2(39.73,186.06) 39.5,185.84 R81.2 ; C70.2 50.01,185.71 v2(50.01,185.11) 50.01,184.58 R93.2 ; R45.2 40.04,190.7 v2(40.17,190.57) C55.2 ; C150.1 v2(9.18,168.09) ; C71.2 v2(54.37,185.13) 54.37,184.23 R94.2 ; Q19.E v2(9.12,171.39) ; v2(10.61,192.82) R42.2 C42.1 ; R11.2 v2(6.96,201.11) ; v2(3.66,163.07) R206.1 v2(4.74,164.03) ; R79.1 v2(10.2,185.45) ; D3.3 v2(6.07,192.98) ; v2(17.5,195.9) 17.5,195.01 C33.2 16.55,195.08 v2(16.55,195.9) ; D5.3 v2(55.61,184.54) ; C14.1 R20.2 v2(10.64,198.35) ; v2(3.91,198.19) D1.3 ; C32.2 v2(18.58,195.4) ; v2(21.85,191.71) C46.2 ; C99.1 8.36,180.85 v2(8.29,180.79) ; R95.2 45.89,184.19 v2(45.89,185.17) C72.2 ; v2(9.25,189.43) C58.2 10.39,190.76 v2(10.33,190.82) ; C69.2 58.84,185.93 58.14,185.24 v2(58.14,184.98) 58.14,184.54 58.52,184.16 R96.2 ; v2(44.4,183.1) 44.87,182.63 R105.1 45.5,182.63 v2(46.1,183.23) ; D6.3 v2(47.14,184.52) ; C141.1 v2(9.18,169.61) ; C61.2 v2(10.26,187.89)
  vias: v2(1.18,207.33) v2(1.25,202) v2(5.37,208.98) v2(18.77,209.11) v2(31.79,209.11) v2(43.66,208.98) v2(49.95,208.98) v2(55.86,208.98) v2(59.35,202.38) v2(59.28,198.7)
BA_PC1:
  vias: v1(191.06,58.03)
BA_PC2: length 5.1
  TOP w0.102: R452.2 193.89,55.41 v2(193.65,55.64) 191.76,55.64 191.11,55 Q41.B
  BOTTOM w0.102: v3(193.65,56.58) v2(193.65,55.64)
BAT_54C_P1: length 3.2
  TOP w0.102: R318.1 v2(10.95,109.89)
  TOP w0.254: D15.1 11.47,109.23 11.66,109.42 R318.1
  BOTTOM w0.102: v2(10.95,109.89) 11.07,109.77 v3(11.07,109.01)
BAT_P2: length 6.3
  TOP w0.254: D15.2 9.57,106.82 v1(8.46,105.71) 8.46,105.18 8.52,105.12 C327.2 R330.1 8.52,102.62 R337.2
BZ_P: length 13.5
  TOP w0.508: C385.1 193.3,62.27 190.49,65.08 BZ.N
CA_REF_RC: length 3.4
  TOP w0.254: C384.2 182.98,60.65 183.49,61.16 v2(183.52,61.16) R433.1
  BOTTOM w0.102: v3(183.52,62.05) v2(183.52,61.16)
CENTER_TAP: length 10.8
  TOP w0.508: C102.1 65.16,181.2 C90.2 65.16,182.22 65.66,182.72 65.66,186.74 65.94,187.01 USB2_LAN.P1
CFG0: length 45.1
  TOP w0.102: CPU.H15 117.26,125.62 v7(117.7,126.07) ; R230.1 91.27,155.76 92.44,155.76 v2(92.81,155.39)
  BOTTOM w0.102: v7(117.7,126.07) 116.88,126.89 116.88,130.31 114.83,132.35 v3(114.83,133.32) 114.83,134.23 108.73,140.34 104.62,140.34 93.08,151.88 93.08,155.12 v2(92.81,155.39)
CFG1: length 46.1
  TOP w0.102: v2(91.22,157.74) 90.84,157.36 R221.1 ; v7(117.68,127.89) CPU.F15
  BOTTOM w0.102: v2(91.22,157.74) 92.06,157.74 92.66,157.14 v3(92.66,156.63) 93.43,155.86 93.43,152.03 104.77,140.7 109.1,140.7 115.93,133.87 115.93,131.74 117.15,130.52 117.15,128.42 v7(117.68,127.89)
CFG2: length 49.9
  TOP w0.102: v2(90.4,159.07) 90.27,158.95 88.14,158.95 R215.1 ; v7(118.62,127.91) CPU.F16
  BOTTOM w0.102: v7(118.62,127.91) 118.62,128.13 117.96,128.78 117.96,132.66 109.21,141.41 104.88,141.41 94.02,152.27 94.02,156.66 91.61,159.07 v3(91.26,159.07) v2(90.4,159.07)
CFG3: length 49.8
  TOP w0.102: v7(118.62,126.08) CPU.H16 ; v2(90.59,158.31) 89.32,158.31 89.19,158.44 R219.1
  BOTTOM w0.102: v2(90.59,158.31) 90.63,158.35 91.95,158.35 93.79,156.51 93.79,152.18 104.91,141.05 109.25,141.05 116.33,133.97 116.33,132.3 v3(116.94,131.69) 117.58,131.06 117.58,128.66 118.16,128.08 118.16,126.54 v7(118.62,126.08)
CFG4: length 43.6
  TOP w0.102: R227.1 92.84,156.22 94.65,154.41 v2(94.65,154.31) ; v7(121.34,127.93) CPU.F19
  BOTTOM w0.102: v2(94.65,154.31) 95.61,153.36 95.61,152.33 105.51,142.42 110.05,142.42 119.81,132.66 v3(119.81,131.69) 120.24,131.26 120.24,129.02 v7(121.34,127.93)
CFG5: length 44.7
  TOP w0.102: R232.1 92.35,154.68 93.4,154.68 v2(94.65,153.42) ; v7(120.43,126.1) CPU.H18
  BOTTOM w0.102: v7(120.43,126.1) 119.99,126.53 v3(119.99,127.86) 119.99,129.29 118.66,130.63 118.66,133.04 109.56,142.13 105.37,142.13 95.29,152.22 95.29,152.79 v2(94.65,153.42)
CFG6: length 50.7
  TOP w0.089: CPU.G21 v7(122.27,126.99)
  TOP w0.102: v2(94.65,156.09) 90.15,160.6 R211.1
  BOTTOM w0.102: v7(122.27,126.99) 122.09,127.18 122.09,129.23 120.75,130.56 120.75,132.41 109.91,143.25 v3(107.7,143.25) 105.33,143.25 105.09,143.49 102.75,145.83 96.11,152.46 96.11,154.63 v2(94.65,156.09)
CFG7: length 51.1
  TOP w0.089: CPU.H20 121.38,126.06 v7(121.38,126.1)
  TOP w0.102: v2(94.65,155.26) 94.65,155.37 94.17,155.86 94.17,156.25 90.77,159.64 89.8,159.64 R216.1
  BOTTOM w0.102: v7(121.38,126.1) 121.82,126.54 121.82,129.12 120.5,130.43 120.5,132.31 110.15,142.65 105.6,142.65 95.83,152.42 95.83,154.07 v3(95.53,154.37) 95.53,154.39 v2(94.65,155.26)
CFG9: length 39.2
  TOP w0.102: v2(94.65,152.53) 93.07,154.12 R234.1 ; v7(118.6,128.82) 118.16,128.38 CPU.E16
  BOTTOM w0.102: v7(118.6,128.82) 118.6,129.7 v3(118.59,129.71) 118.28,130.03 118.28,132.9 109.4,141.78 105.02,141.78 94.65,152.14 v2(94.65,152.53)
CFG_RCOMP: length 4.3
  TOP w0.203: CPU.M11 114.15,121.4 114.43,121.4
  TOP w0.305: R291.1 116.37,119.46 114.43,121.4
CHA_D0_EVENT_L: length 7.1
  TOP w0.102: DIMM2.78 109.32,49.49 109.32,47.44 111.45,45.31 R462.2
CHB_D0_EVENT_L: length 4
  TOP w0.102: DIMM1.78 108.65,42.84 108.4,43.09 R461.2
CLK0_24M: length 15.8
  TOP w0.089: PCH1.BC17 38.77,92.06 38.55,92.28 38.23,92.28 38.21,92.26 36.99,92.26 35.98,91.26 35.98,88.55 34.09,86.66 34.09,85.15 33.86,84.92 33.86,83.2 33.05,82.4 C356.1 32.74,82.4 32.71,82.43 32.02,82.43
  TOP w0.102: 32.02,82.43 R371.1 R372.1
CLK1_24M: length 16.4
  TOP w0.089: v4(41.72,91.4) PCH1.AV19
  TOP w0.102: v4(30.89,85.54) 30.72,85.71 C352.1 R365.1
  BOTTOM w0.102: v4(30.89,85.54) 31.27,85.54 36.4,90.67 37.14,90.67 v3(37.77,91.31) 38.13,91.66 39.68,91.66 39.83,91.82 41.31,91.82 v4(41.72,91.4)
CLKREQB: length 3.2
  TOP w0.102: U19.12 56.96,164.42 56.87,164.33 55.8,164.33 v1(55.63,164.15) 55.19,164.15 R193.1
CLKRUN_L: length 17.5
  TOP w0.089: v4(40.71,90.36) 40.61,90.21 PCH1.AW22
  TOP w0.102: v4(28.87,81.92) 28.7,81.76 R373.1
  BOTTOM w0.089: v4(40.71,90.36) 40.27,89.92 38.77,89.92 37.46,88.61 36.07,88.61 31.93,84.47 v3(31.93,83.97)
  BOTTOM w0.102: v3(31.93,83.97) 31.47,83.97 31.01,83.5 29.75,83.5 28.87,82.62 v4(28.87,81.92)
CLR_CMOS_P3: length 2.2
  TOP w0.508: R465.1 26.68,37.82 CLR_CMOS.3
COM1_CTS_L: length 21.3
  TOP w0.102: U35.126 172.44,32.46 v2(172.25,32.64) ; U33.14 v2(154.75,31.48)
  BOTTOM w0.102: v2(172.25,32.64) 171.87,33.03 161.51,33.03 v3(161.19,32.71) 160.71,32.23 155.49,32.23 v2(154.75,31.48)
COM1_DCD_L: length 26.7
  TOP w0.102: U33.19 v2(151.5,28.53) ; U35.124 v2(173.24,32.64)
  BOTTOM w0.102: v2(173.24,32.64) 173.24,32.63 172.55,31.93 171.26,31.93 170.83,32.37 164.31,32.37 163.6,31.65 157.29,31.65 156.29,30.65 v3(155.19,30.65) 153.62,30.65 v2(151.5,28.53)
COM1_DSR_L: length 29.5
  TOP w0.102: v2(153.01,28.52) 152.8,28.73 U33.17 ; U35.120 174.84,32.36 174.92,32.44 174.92,32.9 v2(175.43,33.41)
  BOTTOM w0.102: v2(153.01,28.52) 153.52,28.01 154.03,28.01 155.23,29.22 155.87,29.22 157.62,30.97 165.01,30.97 165.72,31.68 169.15,31.68 v3(169.55,31.29) 169.58,31.25 173.72,31.25 174.92,32.44 174.92,32.9 v2(175.43,33.41)
COM1_DTR_L: length 23.1
  TOP w0.102: v2(155.58,31.46) 155.4,31.29 U33.13 ; U35.123 173.64,32.36 173.72,32.44 173.72,32.95 v2(173.27,33.41)
  BOTTOM w0.102: v2(155.58,31.46) 156.11,32 162.51,32 v3(162.89,32.38) 163.13,32.62 171.12,32.62 171.58,32.16 172.45,32.16 172.76,32.47 172.76,32.9 v2(173.27,33.41)
COM1_NCTS_L: length 16.3
  TOP w0.102: U33.7 154.75,23.22 155.42,22.55 C521.2 154.92,21.88 154.92,19.94 154.36,19.39 149.84,19.39 146.58,16.13 COM.8
COM1_NDCD_L: length 22.8
  TOP w0.102: COM.1 137.33,14.86 136.46,15.73 136.46,16.49 136.97,17 139.18,17 140.1,17.91 146.47,17.91 148.84,20.29 148.84,21.65 149.58,22.39 C516.2 150.57,22.93 151.17,22.93 151.5,23.26 U33.2
COM1_NDSR_L: length 15.2
  TOP w0.102: COM.6 143.73,17.46 146.9,17.46 149.52,20.07 151.3,20.07 151.68,20.45 151.68,21.88 C518.2 152.8,23 U33.4
COM1_NDTR_L: length 30
  TOP w0.102: COM.4 138.72,14.99 138.72,13.34 139.48,12.58 145.58,12.58 146.22,13.21 146.22,15.44 149.93,19.16 154.76,19.16 155.93,20.33 155.93,21.51 156.5,22.08 C522.2 156.22,22.39 155.4,23.21 U33.8
COM1_NRI_L: length 22.5
  TOP w0.102: C523.2 157.04,22.93 156.38,22.93 156.05,23.26 U33.9 ; C523.2 157.99,22.39 158.95,21.44 R531.1 ; C523.2 157.58,22.08 158.01,21.65 158.01,20.88 156.06,18.93 150.03,18.93 147.49,16.39 COM.9
COM1_NRTS_L: length 18.9
  TOP w0.102: U33.6 154.1,23.11 154.34,22.87 C520.2 153.86,21.91 153.86,20.1 153.38,19.61 149.74,19.61 147.13,17 144.59,17 144.08,16.49 144.08,14.46 COM.7
COM1_NSIN: length 19.2
  TOP w0.102: U33.3 152.15,23.21 151.33,22.39 C517.2 150.6,21.88 150.6,21.02 150.06,20.48 149.55,20.48 146.75,17.68 140.19,17.68 138.64,16.13 COM.2
COM1_NSOUT: length 20.4
  TOP w0.102: COM.3 141.2,14.93 143.23,14.93 143.85,15.55 143.85,16.59 144.49,17.23 147.03,17.23 149.65,19.84 152.34,19.84 152.76,20.26 152.76,21.88 C519.2 153.45,22.57 U33.5
COM1_RI_L: length 18.9
  TOP w0.102: v2(157.2,33.22) 157.53,32.88 D21.N ; v2(172.25,33.41) 172.73,32.92 172.73,32.24 172.84,32.14 U35.125
  BOTTOM w0.102: v2(157.2,33.22) v3(158.45,33.22) 158.64,33.41 v2(172.25,33.41)
COM1_RI_L_IC: length 4.8
  TOP w0.102: U33.12 156.05,28.97 156.53,28.49 v2(156.59,28.49) 157.05,28.49 157.92,29.36 D21.P
  BOTTOM w0.102: v3(157.12,29.18) 156.59,28.64 v2(156.59,28.49)
COM1_RTS_L: length 26.5
  TOP w0.102: v2(175.43,32.64) 175.24,32.46 U35.119 ; U33.15 154.1,29.08 154.66,28.52 v2(155.36,28.52)
  BOTTOM w0.102: v2(155.36,28.52) 155.55,28.52 157.77,30.74 164.68,30.74 165.23,30.19 166.65,30.19 v3(167.13,30.68) 167.6,30.68 168,30.28 169.88,30.28 170.61,31.02 173.82,31.02 175.15,32.35 175.15,32.37 v2(175.43,32.64)
COM1_SIN: length 28.6
  TOP w0.102: v2(174.41,33.41) 173.96,32.95 173.96,32.44 174.04,32.36 U35.122 ; v2(152.25,28.52) 152.15,28.62 U33.18
  BOTTOM w0.102: v2(152.25,28.52) 153.26,29.53 v3(153.47,29.53) 153.87,29.94 155.91,29.94 157.39,31.43 163.73,31.43 164.44,32.14 170.64,32.14 171.07,31.7 172.98,31.7 173.96,32.68 173.96,32.95 v2(174.41,33.41)
COM1_SOUT: length 25.6
  TOP w0.102: U33.16 153.45,28.97 v2(153.84,28.58) ; U35.121 v2(174.44,32.64)
  BOTTOM w0.102: v2(153.84,28.58) 154.79,29.53 155.85,29.53 157.52,31.2 164.33,31.2 v3(164.67,31.54) 165.04,31.91 170.45,31.91 170.88,31.48 173.27,31.48 v2(174.44,32.64)
COM_+12V: length 5.2
  TOP w0.102: D22.N 149.14,22.64 v1(149.12,22.62)
  TOP w0.254: D22.N 149.14,24.96 149.52,25.34 150.6,25.34 150.85,25.09 U33.1
COPEN_L: length 4.6
  TOP w0.102: U35.65 186.88,17.25 v1(187.05,17.09) 187.24,16.9 C545.1 188.22,15.18 R550.1
CPU_24MCLK_N: length 75.6
  TOP w0.089: CPU.J9 111.3,124.25 v7(111.28,124.25)
  TOP w0.102: PCH1.F1 57.12,100.11 57.12,101.37 58.75,103 62.37,103 v4(62.65,102.72)
  BOTTOM w0.089: v7(111.28,124.25) 111.63,123.89 111.63,123.31 110.97,122.65 110.97,117.59 110.51,117.13 109.43,117.13 109.42,117.14 109.4,117.14
  BOTTOM w0.102: 109.4,117.14 106.8,117.14 106.39,117.54 100.6,117.54 99.73,116.67 92.04,116.67 90.3,118.41 86.25,118.41 83.02,115.18 74.91,115.18 73.79,114.06 69.96,114.06 63.61,107.71 62.86,107.71 61.63,106.49 61.63,103.35 61.98,103 62.37,103 v4(62.65,102.72)
CPU_24MCLK_P: length 75.7
  TOP w0.089: CPU.K9 112.19,124.23 v7(112.19,124.25)
  TOP w0.102: PCH1.G1 56.81,99.99 56.92,100.1 56.92,101.46 58.66,103.21 62.37,103.21 v7(62.65,103.49)
  BOTTOM w0.089: 109.4,116.93 109.41,116.93 109.42,116.94 110.59,116.94 111.16,117.52 111.16,122.57 111.82,123.23 111.82,123.88 v7(112.19,124.25)
  BOTTOM w0.102: 109.4,116.93 106.71,116.93 106.31,117.34 100.69,117.34 99.81,116.46 91.95,116.46 90.21,118.2 86.33,118.2 83.1,114.98 74.99,114.98 73.87,113.86 70.05,113.86 63.7,107.51 62.94,107.51 61.84,106.41 61.84,103.43 62.07,103.21 62.37,103.21 v7(62.65,103.49)
CPU_BCLK_N: length 63.3
  TOP w0.102: v7(63.16,105.01) 62.88,104.73 62.09,104.73 61.37,104.01 58.45,104.01 56.17,101.73 PCH1.H2 ; CPU.W4 v7(107.64,116.02)
  BOTTOM w0.102: v7(63.16,105.01) 63.44,104.73 64.26,104.73 64.9,105.36 64.9,106.96 67.93,110 71.75,110 75.53,113.78 83.61,113.78 86.86,117.04 89.64,117.04 91.42,115.26 101.73,115.26 102.26,114.72 104.26,114.72 105.11,115.58 107.2,115.58 v7(107.64,116.02)
CPU_BCLK_P: length 63.2
  TOP w0.102: CPU.W5 107.91,115.56 107.64,115.29 v7(107.64,115.11) ; PCH1.G2 56.67,99.48 56.38,99.78 56.38,101.65 58.53,103.81 61.46,103.81 62.18,104.53 62.88,104.53 v4(63.16,104.25)
  BOTTOM w0.102: v7(107.64,115.11) 107.38,115.37 105.19,115.37 104.34,114.52 102.18,114.52 101.64,115.05 91.33,115.05 89.55,116.83 86.94,116.83 83.69,113.58 75.62,113.58 71.83,109.8 68.02,109.8 65.1,106.88 65.1,105.28 64.35,104.53 63.44,104.53 v4(63.16,104.25)
CPU_J11: length 1.7
  TOP w0.089: CPU.J11 113.59,124.7 v4(113.11,124.22)
  BOTTOM w0.089: v4(113.11,124.22) 113.59,124.71 STP2.1
CPU_K13: length 6
  TOP w0.089: R292.1 115.04,121.37 115.04,123.41 CPU.K13
CPU_PCIBCLK_N: length 60.7
  TOP w0.102: PCH1.J1 55.57,100.04 55.57,101.83 58.27,104.53 61.19,104.53 62.78,106.11 63.26,106.11 v4(63.54,105.83) ; CPU.W2 105.14,115.56 104.9,115.8 v7(104.9,116.02)
  BOTTOM w0.102: v4(63.54,105.83) 63.82,106.11 64.11,106.11 64.36,106.37 64.36,107.16 70.18,112.97 73.99,112.97 75.29,114.27 83.39,114.27 86.64,117.52 89.92,117.52 91.67,115.77 102.02,115.77 102.53,115.26 104.07,115.26 104.42,115.61 104.42,115.92 104.6,116.1 104.82,116.1 v7(104.9,116.02)
CPU_PCIBCLK_P: length 60.8
  TOP w0.102: v7(63.54,106.6) 63.26,106.32 62.69,106.32 61.1,104.73 58.18,104.73 55.37,101.91 55.37,99.86 55.51,99.71 55.52,99.71 55.7,99.53 PCH1.J2 ; CPU.W1 v7(103.99,116.02)
  BOTTOM w0.102: v7(63.54,106.6) 63.82,106.32 64.03,106.32 64.16,106.45 64.16,107.24 70.09,113.18 73.91,113.18 75.2,114.47 83.3,114.47 86.56,117.72 90,117.72 91.75,115.97 102.11,115.97 102.62,115.46 103.99,115.46 104.22,115.69 104.22,115.79 103.99,116.02 v7(103.99,116.02)
CPU_PLTRST_L: length 70.3
  TOP w0.089: 46.06,105.69 46.06,105.23 45.22,104.39 45.22,99.84 45.27,99.8 45.27,99.8 45.46,99.61 PCH1.AK2
  TOP w0.102: 46.06,105.69 46.06,106.46 49.53,109.92 50.52,109.92 51.23,110.64 51.23,114.45 52.68,115.89 55.97,115.89 57.69,117.61 v2(58.29,117.61) ; R235.1 71.86,152.6 70.64,151.37 v2(70.2,151.37)
  BOTTOM w0.102: v2(70.2,151.37) 68.68,149.85 v3(68.28,149.85) 67.29,148.86 65.68,148.86 59.79,142.97 59.79,119.11 v2(58.29,117.61)
CPU_PM_DOWN: length 53
  TOP w0.102: v2(75.41,151.39) 75.29,151.52 R238.2 ; v7(110.39,129.74) CPU.D8
  BOTTOM w0.102: v7(110.39,129.74) 110.82,130.17 110.82,133.13 v3(109.77,134.18) 106.83,137.11 103.28,137.11 89.67,150.72 89.67,153.08 87.1,155.65 83.42,155.65 79.68,151.91 75.93,151.91 v2(75.41,151.39)
CPU_PM_SYNC: length 105.7
  TOP w0.102: CPU.E8 v7(110.39,128.82) ; v2(59.41,116.85) 58.84,116.85 56.65,114.65 R299.2
  BOTTOM w0.102: v2(59.41,116.85) 59.41,117.22 60.6,118.41 60.6,142.61 65.99,148 68.4,148 72.64,152.24 v3(74.6,152.24) 79.36,152.24 83.18,156.06 87.26,156.06 90.08,153.24 90.08,150.64 103.38,137.34 107.39,137.34 111.15,133.59 111.15,129.81 110.39,129.05 v7(110.39,128.82)
CPU_PWROK: length 60.9
  TOP w0.102: R297.2 51.39,117.11 54.45,117.11 v2(55.98,118.65) ; R222.1 77.01,156.57 v2(75.29,156.57)
  BOTTOM w0.102: v2(55.98,118.65) 56.64,119.31 56.64,136.43 v3(55.31,137.76) 55.31,141.73 68.08,154.5 71.96,154.5 74.03,156.57 v2(75.29,156.57)
CPU_PWROK_RC: length 54.1
  TOP w0.102: v2(83.86,157.49) 82.72,157.49 81.76,158.44 C194.1 79.76,158.23 78.44,156.91 R222.2 ; v7(110.39,127.91) CPU.F8
  BOTTOM w0.102: v2(83.86,157.49) 84.37,156.98 87.5,156.98 90.89,153.58 90.89,150.98 103.71,138.16 107.73,138.16 112.45,133.44 112.45,131.84 111.76,131.16 111.76,128.72 v3(111.53,128.49) 110.95,127.91 v7(110.39,127.91)
CPU_RST_L_RC: length 52.1
  TOP w0.102: v7(109.47,128.82) CPU.E7 ; R235.2 C203.1 75.1,153.68 76.24,152.53 v2(76.24,151.33)
  BOTTOM w0.102: v7(109.47,128.82) 109.55,128.82 109.95,129.23 109.95,130.93 110.41,131.39 110.41,132.71 v3(106.78,136.34) 106.46,136.66 103.24,136.66 93.08,146.82 83.41,146.82 80.79,149.44 80.79,150.46 79.63,151.62 76.53,151.62 v2(76.24,151.33)
CPU_VIDALERT_L: length 25.8
  TOP w0.102: CPU.E39 141.71,127.45 142.13,127.03 142.57,127.03 145.61,130.07 145.61,133.24 147.67,135.3 160.71,135.3 160.92,135.51 R266.2
CPU_VIDSCK: length 28.2
  TOP w0.102: CPU.E38 140.82,127.45 141.35,126.92 141.71,126.92 141.92,126.7 141.92,126.38 142.01,126.29 142.22,126.08 143.39,126.08 143.65,126.35 143.65,127.43 146.09,129.87 146.09,133.04 147.87,134.82 160.44,134.82 160.82,134.44 R270.2
CPU_VIDSOUT: length 27.5
  TOP w0.102: R261.2 160.95,136.59 160.13,135.78 147.47,135.78 145.12,133.44 145.12,131.63 143.23,129.74 arc(143.23,129.4) 143.58,129.4 144.1,129.93 arc(144.44,129.93) 144.44,129.58 CPU.E40
CPU_VSS_AB10: length 13
  TOP w0.089: PCH1.AB10 49.57,95.83 v4(50.12,96.26) ; 54.78,105.69 54.78,104.95 v4(54.24,104.42)
  TOP w0.102: 54.78,105.69 SP16.2
  BOTTOM w0.102: v4(54.24,104.42) 53.7,103.87 v3(53.7,103.07) 53.32,102.69 53.32,98.33 52.49,97.5 51.37,97.5 v4(50.12,96.26)
CPU_VSS_AB11: length 14.3
  TOP w0.089: 56.05,105.69 56.05,105.47 v4(54.28,103.7) ; PCH1.AB11 49.55,95.07 v4(50.06,95.58)
  TOP w0.102: 56.05,105.69 SP17.2
  BOTTOM w0.102: v4(54.28,103.7) 54.28,101.69 v3(53.92,101.34) 53.52,100.94 53.52,98.12 52.71,97.3 51.45,97.3 50.59,96.44 50.59,96.11 v4(50.06,95.58)
DCPRTC: length 21.6
  TOP w0.203: v4(40.2,87.98) 40.2,87.75 PCH1.BA26 ; v2(33.77,73.93) 33.77,73.74 32.71,72.68 C370.1
  BOTTOM w0.203: v2(33.77,73.93) 34.44,74.61 34.44,75.74 34.09,76.09 v3(34.09,81.98) 33.81,82.26 33.81,84.57 36.53,87.29 39.29,87.29 39.98,87.98 v4(40.2,87.98)
DDI1_AUX_N: length 81.4
  TOP w0.089: 110.73,134.42 110.74,134.4 110.75,134.4 112.31,132.85 114.32,132.85 114.89,132.28 114.89,130.72 115.13,130.48 115.3,130.48 115.42,130.37 CPU.C13
  TOP w0.102: 110.73,134.42 110.07,135.07 106.4,135.07 95.4,146.07 95.4,156.42 92.56,159.26 92.56,160.66 91.59,161.63 91.05,161.63 v7(90.72,161.3) ; v2(105.5,189.49) 105.17,189.82 105.17,190 C48.1
  BOTTOM w0.102: v2(105.5,189.49) 105.17,189.16 105.17,181.21 91.61,167.65 91.61,161.97 91.27,161.64 91.06,161.64 v7(90.72,161.3)
DDI1_AUX_P: length 81.3
  TOP w0.089: 110.87,134.56 110.89,134.55 110.89,134.54 112.39,133.04 114.4,133.04 115.08,132.36 115.08,130.8 115.2,130.67 115.3,130.67 115.42,130.79 CPU.B13
  TOP w0.102: v2(90.72,162.16) 91.05,161.83 91.68,161.83 92.76,160.74 92.76,159.35 95.61,156.5 95.61,146.15 106.49,135.27 110.16,135.27 110.87,134.56 ; v7(104.64,189.49) 104.97,189.82 104.97,189.94 C47.1
  BOTTOM w0.102: v2(90.72,162.16) 91.03,161.84 91.19,161.84 91.4,162.06 91.4,167.73 104.97,181.29 104.97,189.16 v7(104.64,189.49)
DDI1_TX_N0: length 86.4
  TOP w0.089: CPU.D21 123.27,129.81 123.27,130.59 121.86,131.99 118.56,135.3 118.56,135.31 118.54,135.32
  TOP w0.102: C51.1 108.92,189.94 108.92,189.81 v2(109.25,189.48) ; v7(103.99,146.63) 103.63,146.27 103.63,143.87 108.56,138.94 114.92,138.94 118.54,135.32
  BOTTOM w0.102: v7(103.99,146.63) 103.68,146.93 103.68,147.35 102.73,148.3 101.27,148.3 96.88,152.7 96.88,155.23 92.32,159.79 92.32,167.37 108.92,183.97 108.92,189.15 v2(109.25,189.48)
DDI1_TX_N1: length 88.8
  TOP w0.089: CPU.E22 123.65,128.66 123.74,128.75 124,128.75 124.19,128.94 124.19,131.25 123.67,131.77 120.14,135.3 120.14,135.31 120.13,135.32
  TOP w0.102: 120.13,135.32 115.55,139.9 108.64,139.9 105.13,143.41 105.13,144.79 v7(105.45,145.1) ; v2(111.61,189.46) 111.3,189.77 111.3,189.92 C53.1
  BOTTOM w0.102: v7(105.45,145.1) 105.07,145.48 105.07,147.3 103.04,149.32 101.24,149.32 97.59,152.98 97.59,155.5 93,160.09 93,167.06 111.28,185.34 111.28,189.13 v2(111.61,189.46)
DDI1_TX_P0: length 86.3
  TOP w0.089: CPU.C21 122.73,129.92 122.86,129.79 122.95,129.79 123.08,129.91 123.08,130.51 118.42,135.16 118.41,135.16 118.4,135.18
  TOP w0.102: C50.1 108.71,189.94 108.71,189.81 v7(108.38,189.48) ; v2(103.1,146.63) 103.43,146.3 103.43,143.78 108.47,138.74 113.77,138.74 113.76,138.74 114.84,138.74 118.4,135.18
  BOTTOM w0.102: v7(108.38,189.48) 108.71,189.15 108.71,184.05 92.11,167.45 92.11,159.71 96.67,155.15 96.67,152.61 101.19,148.1 102.64,148.1 103.48,147.26 103.48,147.01 v2(103.1,146.63)
DDI1_TX_P1: length 88.8
  TOP w0.089: 119.98,135.18 120,135.16 120.01,135.16 124,131.17 124,129.01 123.92,128.94 123.76,128.94 123.65,129.05 CPU.D22
  TOP w0.102: 119.98,135.18 115.47,139.7 108.56,139.7 104.93,143.33 104.93,144.73 v2(104.56,145.1) ; v7(110.74,189.46) 110.99,189.46 111.1,189.58 111.1,190.21 110.9,190.41 C52.1
  BOTTOM w0.102: v2(104.56,145.1) 104.86,145.41 104.86,147.21 102.96,149.12 101.16,149.12 97.38,152.89 97.38,155.42 92.8,160 92.8,167.15 111.07,185.42 111.07,189.35 110.96,189.46 v7(110.74,189.46)
DDI3_TX_N0: length 101.7
  TOP w0.089: 111.89,134.56 111.95,134.5 111.95,134.49 112.77,133.67 115.29,133.67 116.12,132.84 116.12,132.41 115.99,132.28 115.99,131.72 116.05,131.66 116.18,131.66 116.33,131.81 CPU.A14
  TOP w0.102: 111.89,134.56 110.49,135.96 106.86,135.96 96.3,146.51 96.3,156.82 94.34,158.79 94.34,160.58 v2(94.63,160.87) ; v7(132.39,196.58) 132.39,196.79 132.51,196.92 133.25,196.92 133.55,196.62 C27.1
  BOTTOM w0.102: v2(94.63,160.87) 94.42,160.87 94.27,161.02 94.27,167.34 109.75,182.82 117.36,182.82 131.53,197 132.21,197 132.39,196.82 v7(132.39,196.58)
DDI3_TX_N1: length 100.2
  TOP w0.089: CPU.B15 117.24,130.8 117.15,130.7 117.02,130.7 116.87,130.85 116.87,132.3 116.75,132.42 116.75,133.1 115.61,134.24 113.47,134.24 113.17,134.54 113.17,134.55 113.16,134.56
  TOP w0.102: 113.16,134.56 111.07,136.64 107.32,136.64 97,146.97 97,157.14 95.71,158.43 95.71,159.07 95.81,159.17 v2(96.04,159.17) ; C31.1 133.55,194.44 133.23,194.75 132.18,194.75 132.07,194.65 v7(132.07,194.42)
  BOTTOM w0.102: v7(132.07,194.42) 132.07,194.66 131.98,194.75 130.27,194.75 117.51,182 109.92,182 95.73,167.81 95.73,159.33 95.89,159.17 v2(96.04,159.17)
DDI3_TX_N2: length 97.5
  TOP w0.089: 113.54,135.32 113.55,135.31 113.55,135.3 113.59,135.26 114.04,134.82 116.06,134.82 118.02,132.85 118.02,132.47 117.89,132.33 117.83,132.28 117.83,131.78 117.95,131.66 118.07,131.66 118.16,131.75 CPU.A16
  TOP w0.102: C43.1 133.11,192.59 131.92,192.59 131.81,192.49 v7(131.81,192.26) ; v2(98.03,158.26) 97.81,158.26 97.7,158.16 97.7,147.54 107.91,137.33 111.53,137.33 113.54,135.32
  BOTTOM w0.102: v2(98.03,158.26) 97.8,158.26 97.61,158.45 97.61,159.7 96.43,160.88 96.43,167.52 110.02,181.11 117.7,181.11 129.19,192.59 131.71,192.59 131.81,192.49 v7(131.81,192.26)
DDI3_TX_N3: length 96.3
  TOP w0.089: CPU.B17 119.07,130.97 118.94,130.83 118.79,130.83 118.69,130.93 118.69,132.36 118.59,132.45 118.59,133.04 117.96,133.67 117.2,134.44 116.38,135.26 116.38,135.26 116.32,135.32
  TOP w0.102: v7(131.87,190.11) 131.87,190.34 132.06,190.52 133.03,190.52 C56.1 ; 116.32,135.32 113.62,138.02 108.29,138.02 98.98,147.32 98.98,153.94 99.07,154.03 v2(99.31,154.03)
  BOTTOM w0.102: v7(131.87,190.11) 131.87,190.32 131.67,190.52 128.13,190.52 117.89,180.28 110.18,180.28 97.13,167.23 97.13,161.27 98.98,159.41 98.98,154.22 99.17,154.03 v2(99.31,154.03)
DDI3_TX_P0: length 101.7
  TOP w0.089: 111.74,134.42 111.76,134.4 111.77,134.4 112.69,133.48 115.21,133.48 115.93,132.76 115.93,132.49 115.8,132.36 115.8,131.64 116.33,131.11 CPU.B14
  TOP w0.102: 111.74,134.42 110.41,135.76 106.77,135.76 96.1,146.43 96.1,156.74 94.13,158.7 94.13,160.5 v7(93.76,160.87) ; C15.1 133.12,197.12 132.71,197.12 v2(132.39,197.45)
  BOTTOM w0.102: v7(93.76,160.87) 94.07,161.17 94.07,167.43 109.67,183.03 117.27,183.03 131.45,197.2 132.14,197.2 v2(132.39,197.45)
DDI3_TX_P1: length 100.2
  TOP w0.089: 113.01,134.42 113.03,134.4 113.04,134.4 113.39,134.05 115.53,134.05 116.56,133.02 116.56,132.34 116.68,132.22 116.68,130.77 116.94,130.51 117.07,130.51 117.24,130.34 CPU.C15
  TOP w0.102: 113.01,134.42 110.99,136.44 107.24,136.44 96.8,146.88 96.8,157.05 95.5,158.35 95.5,158.84 v7(95.17,159.17) ; C29.1 133.11,194.96 132.4,194.96 v2(132.07,195.29)
  BOTTOM w0.102: v2(132.07,195.29) 131.74,194.96 130.19,194.96 117.43,182.2 109.83,182.2 95.53,167.9 95.53,159.53 v7(95.17,159.17)
DDI3_TX_P2: length 97.5
  TOP w0.089: CPU.B16 118.16,131.31 118,131.47 117.88,131.47 117.64,131.7 117.64,132.36 117.7,132.41 117.83,132.55 117.83,132.78 115.98,134.63 113.96,134.63 113.46,135.13 113.41,135.17 113.41,135.17 113.39,135.18
  TOP w0.102: v7(97.17,158.26) 97.5,157.93 97.5,147.45 107.82,137.13 111.45,137.13 113.39,135.18 ; v2(131.81,193.13) 132.14,192.8 133.11,192.8 C41.1
  BOTTOM w0.102: v7(97.17,158.26) 97.41,158.51 97.41,159.62 96.23,160.8 96.23,167.6 109.94,181.31 117.62,181.31 129.11,192.8 131.48,192.8 v2(131.81,193.13)
DDI3_TX_P3: length 96.4
  TOP w0.089: 116.17,135.18 116.18,135.17 116.19,135.17 116.23,135.13 118.4,132.96 118.4,132.38 118.5,132.28 118.5,130.86 119.07,130.28 CPU.C17
  TOP w0.102: C45.1 133.19,190.72 132.12,190.72 v2(131.87,190.97) ; 116.17,135.18 113.54,137.81 108.2,137.81 98.78,147.24 98.78,153.7 v7(98.45,154.03)
  BOTTOM w0.102: v7(98.45,154.03) 98.78,154.36 98.78,159.33 96.93,161.18 96.93,167.32 110.1,180.49 117.81,180.49 128.05,190.72 131.62,190.72 v2(131.87,190.97)
DDR4_DRAMRST_L: length 17.5
  TOP w0.102: R473.2 130.09,36.63 129.02,37.7 129.02,38.54 DIMM1.58 130.8,40.32 130.8,44.25 129.87,45.18 129.87,46.66 130.75,47.54 DIMM2.58
